options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_command: bash -c 'export LD_LIBRARY_PATH="$(dirname "$2")/../../../../gr-foo-fixed/build/lib${{LD_LIBRARY_PATH:+:$LD_LIBRARY_PATH}}"; exec "$1" -u "$2"' -- {python} {filename}
    run_options: run
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in AI-model-CNN-Channel-est/test/until_sync_short.
    value: str(__import__("pathlib").Path(globals().get("__file__", "AI-model-CNN-Channel-est/test/until_sync_short/wifi_rx.py")).resolve().parents[2] / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Pipeline kernel built by the local Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "AI-model-CNN-Channel-est/test/until_sync_short/wifi_rx.py")).resolve().parent / "build")
  states: {}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: data_dir + "/tmp_out/until_sync_short_replaced.iqdata"
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data_dir + "/tmp_out/until_sync_short_replaced.pcap"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: "#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n#\n# Copyright 2026 gr-mlir_aie author.\n#\n# SPDX-License-Identifier: GPL-3.0-or-later\n#\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nfrom aie.dialects.aie import *\nfrom aie.extras.context import mlir_mod_ctx\nfrom aie.iron import Program, Runtime, Worker, ObjectFifo\nfrom aie.iron.placers import SequentialPlacer\nfrom aie.iron.controlflow import range_\n\nimport aie.iron as iron\nfrom aie.utils import NPUKernel, DefaultNPURuntime, get_current_device\n\nDEV = iron.get_current_device()\nDTYPE_IN=np.int32\nDTYPE_OUT=np.int32\n\nclass mlir_aie_python_int32(gr.basic_block):\n    \"\"\"\n    docstring for block mlir_aie_python_int32\n    \"\"\"\n    def __init__(self, path_xclbin=\"build/final.xclbin\",path_insts_bin=\"build/insts.bin\", VECTOR_SIZE = 4096):\n        gr.basic_block.__init__(self,\n            name=\"mlir_aie_python_int32\",\n            in_sig=[DTYPE_IN, ],\n            out_sig=[DTYPE_OUT, ])\n            \n        self.kernel_paths = (path_xclbin, path_insts_bin)\n        self.set_tag_propagation_policy(gr.TPP_DONT)\n        self.OUT_SAMPLE_OFFSET = 320\n        self.VECTOR_SIZE = VECTOR_SIZE\n        self.TILE_SIZE = VECTOR_SIZE // 4\n        self.OUT_TILE_SIZE = self.TILE_SIZE + self.OUT_SAMPLE_OFFSET\n        self.OUT_VECTOR_SIZE = self.OUT_TILE_SIZE * 4\n        self.out_buf = iron.zeros(self.OUT_VECTOR_SIZE, dtype=DTYPE_OUT)\n        self.MAX_TAGS_PER_TILE = 7\n        self.METADATA_WORDS_PER_TILE = 2 + 2 * self.MAX_TAGS_PER_TILE\n        self.out_meta_buf = iron.zeros(4 * self.METADATA_WORDS_PER_TILE, dtype=np.int32)\n        self.tag_key = pmt.intern(\"wifi_start\")\n        self.tag_srcid = pmt.intern(\"sync_short\")\n        \n        self.set_output_multiple(4096)\n        self.set_min_output_buffer(4096)\n\n    def start(self):\n        npu_kernel = NPUKernel(*self.kernel_paths, kernel_name=\"MLIR_AIE\")\n        self.kernel_handle = DefaultNPURuntime.load(npu_kernel)\n        return True\n\n    #TODO implement forecast()\n    def forecast(self, noutput_items, ninputs):\n        #ninput_items_required = [min(self.VECTOR_SIZE, noutput_items)] * ninputs\n        ninput_items_required = [noutput_items] * ninputs   \n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        n_input_items = len(in0)\n        n_output_items = len(out0)\n        \n        #print(f\"{len(in0)} {len(out0)}\")\n        n_chunks = min(n_input_items // self.VECTOR_SIZE, n_output_items // self.VECTOR_SIZE)\n\n        if n_chunks == 0:\n            return 0\n\n        total_produced = 0\n        for i in range(n_chunks):\n            start_idx = i * self.VECTOR_SIZE\n            end_idx = start_idx + self.VECTOR_SIZE\n            \n            current_in_tensor = iron.tensor(in0[start_idx:end_idx], dtype=DTYPE_IN)\n            buffers = [current_in_tensor, self.out_buf, self.out_meta_buf]\n            DefaultNPURuntime.run(self.kernel_handle, buffers)\n\n            out_np = self.out_buf.numpy()\n            out_meta = self.out_meta_buf.numpy().reshape(4, self.METADATA_WORDS_PER_TILE)\n            output_abs_start = self.nitems_written(0)\n            for tile_idx, tile_meta in enumerate(out_meta):\n                tile_len = int(tile_meta[0])\n                tag_count = min(int(tile_meta[1]), self.MAX_TAGS_PER_TILE)\n                tile_start = tile_idx * self.OUT_TILE_SIZE + self.OUT_SAMPLE_OFFSET\n                tile_end = tile_start + tile_len\n                next_total_produced = total_produced + tile_len\n                out0[total_produced:next_total_produced] = out_np[tile_start:tile_end]\n\n                tile_abs_start = output_abs_start + total_produced\n                for tag_idx in range(tag_count):\n                    tag_offset = int(tile_meta[2 + 2 * tag_idx])\n                    tag_value = float(tile_meta[3 + 2 * tag_idx]) / (1 << 29)\n                    if 0 <= tag_offset < tile_len:\n                        self.add_item_tag(\n                            0,\n                            tile_abs_start + tag_offset,\n                            self.tag_key,\n                            pmt.from_double(tag_value),\n                            self.tag_srcid,\n                        )\n\n                total_produced = next_total_produced\n        \n        total_processed = n_chunks * self.VECTOR_SIZE\n        self.consume_each(total_processed)\n        \n        return total_produced\n\n"
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: mlir_aie_cint16_to_complex64_0
  id: mlir_aie_cint16_to_complex64
  parameters: {}
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters: {}
  states: {}
- name: mlir_aie_mlir_aie_cpp_tagged_int32_to_int32_0
  id: mlir_aie_mlir_aie_cpp_tagged_int32_to_int32
  parameters:
    N_TILES: '4'
    VECTOR_SIZE: '4096'
    kernel_name: MLIR_AIE
    num_slots: '2'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {state: disabled}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', mlir_aie_cint16_to_complex64_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_file_meta_sink_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_cint16_to_complex64_0, '0', blocks_delay_0, '0']
- [mlir_aie_cint16_to_complex64_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', epy_block_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_cpp_tagged_int32_to_int32_0, '0']
- [mlir_aie_mlir_aie_cpp_tagged_int32_to_int32_0, '0', mlir_aie_cint16_to_complex64_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
