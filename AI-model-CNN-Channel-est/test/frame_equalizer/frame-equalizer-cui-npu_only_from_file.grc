options:
  parameters:
    category: Custom
    description: Run the standalone frame equalizer NPU kernel on recorded FFT output.
    generate_options: no_gui
    id: frame_equalizer_test
    output_language: python
    run_options: run
    title: Frame Equalizer Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    comment: Hard decisions and reconstructed frame equalizer tags
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../data/tmp_out/__npu.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    comment: Hard decisions and reconstructed frame equalizer tags
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../data/tmp_out/__original.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    comment: Recorded, scalarized complex output of the FFT block
    detached: 'True'
    file: /home/piloteer/바탕화면/fft_full.iqdata
    hdr_file: /home/piloteer/바탕화면/fft_full.iqdata.hdr
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../../data/tmp_out/orig.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ../../data/tmp_out/npu.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import tempfile

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel


      N_TILES = 4
      FFT_MAX_TAGS = 31
      FFT_METADATA_WORDS = 2 + 2 * FFT_MAX_TAGS
      MAX_OUTPUT_TAGS = 16
      CSI_SIZE = 64
      Q16_15_SCALE = 1 << 15
      Q29_SCALE = 1 << 29

      CSI_DTYPE = np.dtype([
          ("real", np.int32),
          ("imag", np.int32),
      ], align=True)
      TAG_METADATA_DTYPE = np.dtype([
          ("offset", np.int32),
          ("frame_start", np.uint32),
          ("frame_bytes", np.uint64),
          ("encoding", np.uint64),
          ("snr_linear", np.uint64),
          ("center_frequency_mhz", np.uint32),
          ("frequency_offset", np.int32),
          ("beta", np.int32),
          ("csi", CSI_DTYPE, (CSI_SIZE,)),
      ], align=True)
      TILE_METADATA_DTYPE = np.dtype([
          ("output_length", np.int32),
          ("tag_count", np.int32),
          ("tags", TAG_METADATA_DTYPE, (MAX_OUTPUT_TAGS,)),
      ], align=True)
      OUTPUT_METADATA_WORDS = (
          N_TILES * TILE_METADATA_DTYPE.itemsize // np.dtype(np.int32).itemsize
      )


      class frame_equalizer_npu(gr.basic_block):
          """Adapt GNU Radio complex samples and tags to the frame equalizer ABI."""

          def __init__(self, path_xclbin="build/final.xclbin",
                       path_insts_bin="build/insts.bin", VECTOR_SIZE=4096, nominal_frequency=2.417e9):
              gr.basic_block.__init__(
                  self,
                  name="frame_equalizer_npu",
                  in_sig=[np.complex64],
                  out_sig=[np.int8],
              )

              if VECTOR_SIZE % N_TILES:
                  raise ValueError("VECTOR_SIZE must be divisible by four")
              if TAG_METADATA_DTYPE.itemsize != 560:
                  raise RuntimeError("frame equalizer tag metadata ABI mismatch")
              if TILE_METADATA_DTYPE.itemsize != 8968:
                  raise RuntimeError("frame equalizer tile metadata ABI mismatch")

              self.path_xclbin = path_xclbin
              self.path_insts_bin = path_insts_bin
              self.kernel_handle = None
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // N_TILES
              self.nominal_frequency = nominal_frequency
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=np.int8)
              self.out_meta_buf = iron.zeros(
                  OUTPUT_METADATA_WORDS, dtype=np.int32)

              self.set_output_multiple(VECTOR_SIZE)
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.wifi_start_key = pmt.intern("wifi_start")
              self.tag_srcid = pmt.intern("frame_equalizer")
              self.tag_keys = {
                  "frame_bytes": pmt.intern("frame bytes"),
                  "encoding": pmt.intern("encoding"),
                  "snr": pmt.intern("snr"),
                  "nominal_frequency": pmt.intern("nominal frequency"),
                  "frequency_offset": pmt.intern("frequency offset"),
                  "beta": pmt.intern("beta"),
                  "csi": pmt.intern("csi"),
              }

          def set_nominal_frequency(self, nominal_frequency):
              self.nominal_frequency = nominal_frequency

          def start(self):
              center_frequency_mhz = round(self.nominal_frequency / 1e6)
              instructions = np.fromfile(self.path_insts_bin, dtype=np.uint32).copy()
              for marker, value in (
                      (0x13579BDF, center_frequency_mhz),
                      (0x2468ACE0, round(20.0 / center_frequency_mhz * (1 << 30)))):
                  matches = np.flatnonzero(instructions == marker)
                  if len(matches) != 1:
                      raise RuntimeError("center-frequency RTP marker is missing or ambiguous")
                  instructions[matches[0]] = np.uint32(value)
              self.rtp_dir = tempfile.TemporaryDirectory()
              patched_insts = os.path.join(self.rtp_dir.name, "insts.bin")
              instructions.tofile(patched_insts)
              kernel = NPUKernel(
                  self.path_xclbin,
                  patched_insts,
                  kernel_name="MLIR_AIE",
              )
              self.kernel_handle = DefaultNPURuntime.load(kernel)
              return True

          def forecast(self, noutput_items, ninputs):
              return [max(self.VECTOR_SIZE, noutput_items)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_chunks = min(
                  len(in0) // self.VECTOR_SIZE,
                  len(out0) // self.VECTOR_SIZE,
              )
              if n_chunks == 0:
                  return 0

              abs_read_start = self.nitems_read(0)
              abs_write_start = self.nitems_written(0)
              total_produced = 0

              for chunk_idx in range(n_chunks):
                  chunk_start = chunk_idx * self.VECTOR_SIZE
                  chunk_end = chunk_start + self.VECTOR_SIZE
                  samples = in0[chunk_start:chunk_end]

                  # Embedded blocks cannot expose s64 ports. Convert complex64 to
                  # the kernel's interleaved Q16.15 cint32 representation here.
                  scaled_real = np.rint(samples.real * Q16_15_SCALE)
                  scaled_imag = np.rint(samples.imag * Q16_15_SCALE)
                  limits = np.iinfo(np.int32)
                  components = np.empty(self.VECTOR_SIZE * 2, dtype=np.int32)
                  components[0::2] = np.clip(
                      scaled_real, limits.min, limits.max).astype(np.int32)
                  components[1::2] = np.clip(
                      scaled_imag, limits.min, limits.max).astype(np.int32)

                  input_metadata = np.zeros(
                      (N_TILES, FFT_METADATA_WORDS), dtype=np.int32)
                  chunk_abs_start = abs_read_start + chunk_start
                  for tile_idx in range(N_TILES):
                      tile_abs_start = chunk_abs_start + tile_idx * self.TILE_SIZE
                      tile_abs_end = tile_abs_start + self.TILE_SIZE
                      tags = self.get_tags_in_range(
                          0, tile_abs_start, tile_abs_end, self.wifi_start_key)
                      tags = tags[:FFT_MAX_TAGS]
                      input_metadata[tile_idx, 0] = self.TILE_SIZE
                      input_metadata[tile_idx, 1] = len(tags)
                      for tag_idx, tag in enumerate(tags):
                          input_metadata[tile_idx, 2 + 2 * tag_idx] = (
                              int(tag.offset) - tile_abs_start)
                          value = pmt.to_double(tag.value)
                          input_metadata[tile_idx, 3 + 2 * tag_idx] = np.int32(
                              np.clip(round(value * Q29_SCALE),
                                      limits.min, limits.max))

                  DefaultNPURuntime.run(
                      self.kernel_handle,
                      [
                          iron.tensor(components, dtype=np.int32),
                          iron.tensor(input_metadata.reshape(-1), dtype=np.int32),
                          self.out_buf,
                          self.out_meta_buf,
                      ],
                  )

                  npu_output = self.out_buf.numpy()
                  metadata = self.out_meta_buf.numpy().view(
                      TILE_METADATA_DTYPE).reshape(N_TILES)
                  for tile_idx, tile_meta in enumerate(metadata):
                      tile_len = max(
                          0, min(int(tile_meta["output_length"]), self.TILE_SIZE))
                      tile_start = tile_idx * self.TILE_SIZE
                      output_start = total_produced
                      output_end = output_start + tile_len
                      out0[output_start:output_end] = npu_output[
                          tile_start:tile_start + tile_len]

                      tile_abs_start = abs_write_start + output_start
                      tag_count = max(
                          0, min(int(tile_meta["tag_count"]), MAX_OUTPUT_TAGS))
                      for tag in tile_meta["tags"][:tag_count]:
                          tag_offset = int(tag["offset"])
                          if 0 <= tag_offset < tile_len:
                              self._add_frame_tags(tile_abs_start + tag_offset, tag)
                      total_produced = output_end

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced

          def _add_frame_tags(self, offset, tag):
              csi = np.empty(CSI_SIZE, dtype=np.complex64)
              csi.real = tag["csi"]["real"] / Q16_15_SCALE
              csi.imag = tag["csi"]["imag"] / Q16_15_SCALE
              values = {
                  "frame_bytes": pmt.from_uint64(int(tag["frame_bytes"])),
                  "encoding": pmt.from_uint64(int(tag["encoding"])),
                  "snr": pmt.from_double(10.0 * np.log10(int(tag["snr_linear"]) / 32.0)),
                  "nominal_frequency": pmt.from_double(int(tag["center_frequency_mhz"]) * 1e6),
                  "frequency_offset": pmt.from_double(
                      int(tag["frequency_offset"]) / Q29_SCALE * 20e6 / (2.0 * np.pi)),
                  "beta": pmt.from_double(int(tag["beta"]) / Q29_SCALE),
                  "csi": pmt.init_c32vector(52, csi[:52].tolist()),
              }
              for name, value in values.items():
                  self.add_item_tag(
                      0, offset, self.tag_keys[name], value, self.tag_srcid)
    comment: Converts complex64 to cint32 internally because Embedded Python blocks do not support s64 ports.
    nominal_frequency: freq
    path_insts_bin: '"build/insts.bin"'
    path_xclbin: '"build/final.xclbin"'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: foo_wireshark_connector_0_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_decode_mac_0_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(0)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_equalizer_test_0
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}

connections:
- [blocks_file_meta_source_0, '0', blocks_probe_rate_0, '0']
- [blocks_file_meta_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_file_meta_source_0, '0', epy_block_0, '0']
- [blocks_file_meta_source_0, '0', mlir_aie_mlir_aie_cpp_equalizer_test_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [blocks_stream_to_vector_0, '0', ieee802_11_frame_equalizer_0, '0']
- [blocks_stream_to_vector_1, '0', ieee802_11_decode_mac_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_meta_sink_0_0, '0']
- [epy_block_0, '0', blocks_file_meta_sink_0, '0']
- [epy_block_0, '0', blocks_stream_to_vector_1, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [foo_wireshark_connector_0_0, '0', blocks_file_sink_0_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0_0, out, foo_wireshark_connector_0_0, in]
- [ieee802_11_frame_equalizer_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [mlir_aie_mlir_aie_cpp_equalizer_test_0, '0', blocks_file_meta_sink_0, '0']
- [mlir_aie_mlir_aie_cpp_equalizer_test_0, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
