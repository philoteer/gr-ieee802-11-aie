options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Differential conformance test for NPU and GNU Radio frame equalizers.
    generate_options: no_gui
    id: test_symbols_grc
    output_language: python
    run_options: run
    title: Frame Equalizer Symbol Conformance Test
  states: {}

blocks:
- name: algorithm
  id: variable
  parameters:
    value: __import__('os').environ.get('EQUALIZER_ALGORITHM', 'LS').lower()
  states: {}
- name: algorithm_id
  id: variable
  parameters:
    value: '{''ls'': 0, ''lms'': 1, ''comb'': 2, ''sta'': 3, ''cnn'': 0}[algorithm]'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: header_damage_mask
  id: variable
  parameters:
    comment: |-
      Flip coded SIGNAL bits 0, 4, and 10 
      only in the final frame.
    value: '[int(i in (432,436,442)) for i in range(480)]'
  states: {}
- name: ltf_words
  id: variable
  parameters:
    comment: |-
      Two standard shifted L-LTF vectors, 
      the direct frame_equalizer preamble.
    value: (tuple((0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0)),)*2
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: Standard 48 legacy data subcarriers.
    value: (list(range(-26,-21))+list(range(-20,-7))+list(range(-6,0))+list(range(1,7))+list(range(8,21))+list(range(22,27)),)
  states: {}
- name: payload_data
  id: variable
  parameters:
    comment: |-
      Deterministic decision labels; 
      standard blocks perform all constellation mapping.
    value: '(lambda n,r: n.concatenate([r.integers(0,m,48,dtype=n.uint8) for m in (2,2,4,4,16,16,64,64)]+[r.integers(0,16,8*48,dtype=n.uint8),r.integers(0,2,48,dtype=n.uint8)]))(__import__(''numpy''),__import__(''numpy'').random.default_rng(80211))'
  states: {}
- name: payload_tags
  id: variable
  parameters:
    comment: |-
      packet_len drives tagged blocks; 
      encoding and psdu_len drive standard 
      WiFi blocks; wifi_start reaches both equalizers.
    value: '(lambda p: [gr.tag_utils.python_to_tag((o,p.intern(k),v,p.PMT_NIL)) for o,n,e,l,c in zip((0,48,96,144,192,240,288,336,384,768),(48,48,48,48,48,48,48,48,384,48),(0,1,2,3,4,5,6,7,5,0),(0,0,0,0,0,0,0,0,130,0),(0.,0.,0.,0.,0.,0.,0.,0.,round(.002*(1<<29))/float(1<<29),0.)) for k,v in ((''packet_len'',p.from_long(n)),(''encoding'',p.from_long(e)),(''psdu_len'',p.from_long(l)),(''wifi_start'',p.from_double(c)))])(__import__(''pmt''))'
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    comment: |-
      Standard 127-symbol IEEE 802.11 pilot 
      polarity sequence.
    value: tuple((p,p,p,-p) for p in (1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,1,1,-1,1,-1,-1,1,1,-1,1,1,-1,1,1,1,1,1,1,-1,1,1,1,-1,1,1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,1,-1,-1,1,-1,-1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,1,-1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: signal_formatter
  id: variable
  parameters:
    comment: |-
      GNU Radio's IEEE 802.11 RATE/LENGTH 
      encoder and interleaver.
    value: ieee802_11.signal_field()
  states: {}
- name: blocks_apply_impairment
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: '64'
  states: {}
- name: blocks_batch_mux
  id: blocks_stream_mux
  parameters:
    comment: Form exactly one 256-vector (16384-sample) NPU batch.
    lengths: (2,47,207)
    num_inputs: '3'
    type: complex
    vlen: '64'
  states: {}
- name: blocks_gnu_decisions_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Collect every GNU Radio hard-decision symbol.
    type: byte
    vlen: '48'
  states: {}
- name: blocks_header_damage_source
  id: blocks_vector_source_x
  parameters:
    comment: Standard XOR mask source for the SIGNAL robustness case.
    repeat: 'False'
    type: byte
    vector: header_damage_mask
  states: {}
- name: blocks_header_payload_mux
  id: blocks_tagged_stream_mux
  parameters:
    comment: Prefix one standard SIGNAL symbol to each payload packet.
    lengthtagname: packet_len
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: blocks_header_xor
  id: blocks_xor_xx
  parameters:
    comment: Corrupt only the final SIGNAL field.
    type: byte
  states: {}
- name: blocks_leading_padding_source
  id: blocks_vector_source_x
  parameters:
    comment: Two leading vectors offset frames across tile boundaries.
    repeat: 'False'
    type: complex
    vector: '[0j] * (2*64)'
    vlen: '64'
  states: {}
- name: blocks_npu_decisions_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Collect every NPU hard-decision symbol and its csi/encoding tags.
    type: byte
    vlen: '48'
  states: {}
- name: blocks_payload_source
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: payload_tags
    type: byte
    vector: payload_data
  states: {}
- name: blocks_stream_to_vector_npu
  id: blocks_stream_to_vector
  parameters:
    comment: Group NPU decisions into 48-carrier symbols.
    num_items: '48'
    type: byte
  states: {}
- name: blocks_symbols_debug
  id: blocks_message_debug
  parameters:
    comment: Store the GNU Radio normalized equalized-symbol PDUs.
  states: {}
- name: blocks_trailing_padding_source
  id: blocks_vector_source_x
  parameters:
    comment: 207 trailing vectors fill the exact NPU batch size.
    repeat: 'False'
    type: complex
    vector: '[0j] * (207*64)'
    vlen: '64'
  states: {}
- name: blocks_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Scalarize the frequency-domain batch for the NPU adapter.
    num_items: '64'
    type: complex
  states: {}
- name: digital_carrier_allocator
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: '64'
    len_tag_key: packet_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: pilot_symbols
    sync_words: ltf_words
  states: {}
- name: digital_signal_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_signal_header
  id: digital_packet_headergenerator_bb
  parameters:
    comment: gr-ieee802-11 SIGNAL encoder/interleaver.
    header_formatter: signal_formatter.formatter()
    len_tag_key: packet_len
  states: {}
- name: ieee802_11_frame_equalizer_reference
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(algorithm_id)
    bw: samp_rate
    comment: Standard GNU Radio receiver reference.
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_payload_symbols
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    comment: per-packet BPSK/QPSK/QAM mapper selected by encoding tags.
  states: {}
- name: imports
  id: import_
  parameters:
    imports: |-
      import numpy as np
      import pmt
  states: {}
- name: mlir_aie_frame_equalizer_npu
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    comment: Existing NPU adapter.
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}
- name: verify
  id: snippet
  parameters:
    code: |-
      import numpy as np
      import pmt

      expected = np.asarray(self.payload_data, dtype=np.uint8).reshape(-1, 48)
      gnu_hard = np.asarray(self.blocks_gnu_decisions_sink.data(), dtype=np.int8).reshape(-1, 48)
      npu_hard = np.asarray(self.blocks_npu_decisions_sink.data(), dtype=np.int8).reshape(-1, 48)
      if gnu_hard.shape != (17, 48) or npu_hard.shape != (17, 48):
          raise AssertionError(
              f'decoded symbol count mismatch: GNU={gnu_hard.shape}, '
              f'NPU={npu_hard.shape}, expected=(17, 48)')

      marker = {}
      with open('build/frame_equalizer_build_mode.txt') as stream:
          for line in stream:
              if '=' in line:
                  key, value = line.split('=', 1)
                  marker[key.strip()] = value.strip()
      if marker.get('ENGINE') == 'AI' or marker.get('EQUALIZER_ALGORITHM') == 'CNN':
          np.testing.assert_array_equal(npu_hard, expected)
      else:
          np.testing.assert_array_equal(npu_hard[:16], gnu_hard[:16])
          np.testing.assert_array_equal(npu_hard[16], expected[16])

      csi = {}
      encodings = {}
      for tag in self.blocks_npu_decisions_sink.tags():
          offset = int(tag.offset)
          key = pmt.symbol_to_string(tag.key)
          if key == 'csi':
              if offset in csi:
                  raise AssertionError(f'duplicate csi tag at symbol {offset}')
              values = np.asarray(pmt.c32vector_elements(tag.value), dtype=np.complex64)
              if values.size < 48:
                  raise AssertionError(
                      f'csi tag at symbol {offset} has {values.size} values; expected at least 48')
              csi[offset] = values[:48]
          elif key == 'encoding':
              if offset in encodings:
                  raise AssertionError(f'duplicate encoding tag at symbol {offset}')
              encodings[offset] = int(pmt.to_uint64(tag.value))
      if sorted(csi) != list(range(17)) or sorted(encodings) != list(range(17)):
          raise AssertionError(
              f'symbol tag coverage mismatch: csi={sorted(csi)}, encodings={sorted(encodings)}')
      actual_encodings = [encodings[i] for i in range(17)]
      wanted_encodings = list(range(8)) + [5] * 8 + [0]
      if actual_encodings != wanted_encodings:
          raise AssertionError(f'encoding tags {actual_encodings!r} != {wanted_encodings!r}')

      debug = self.blocks_symbols_debug
      if debug.num_messages() != 17:
          raise AssertionError(
              f'GNU Radio emitted {debug.num_messages()} symbol PDUs; expected 17')
      gnu_symbols = np.asarray([
          np.asarray(pmt.c32vector_elements(pmt.cdr(debug.get_message(i))), dtype=np.complex64)
          for i in range(17)])
      if gnu_symbols.shape != (17, 48):
          raise AssertionError(f'GNU Radio symbol PDU shape mismatch: {gnu_symbols.shape}')
      npu_symbols = np.asarray([csi[i] for i in range(17)])

      def check_error(label, actual, reference, limit):
          error = actual - reference
          evm = np.sqrt(np.mean(abs(error) ** 2) / np.mean(abs(reference) ** 2))
          gain = np.vdot(reference.ravel(), actual.ravel()) / np.vdot(
              reference.ravel(), reference.ravel())
          print(f'{label}: rms_evm={100 * evm:.5f}% max_abs={np.max(abs(error)):.7f} '
                f'gain={abs(gain):.8f} phase={np.angle(gain):.8g} rad')
          if not evm < limit:
              raise AssertionError(f'{label}: EVM {evm} is not below {limit}')

      cnn = marker.get('EQUALIZER_ALGORITHM') == 'CNN'
      check_error('all rates, flat channel', npu_symbols[:8], gnu_symbols[:8], 3e-2 if cnn else 5e-4)
      check_error('frequency-selective tracked frame',
                  npu_symbols[8:16], gnu_symbols[8:16], 3e-2 if cnn else 2e-3)
      print(f'frame_equalizer {self.algorithm} GRC symbol comparison passed')
    comment: Compare decisions, tags, and symbol EVM; runs after the flowgraph stops.
    section: main_after_stop
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: qam_modulated
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: test_payload
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: qam_modulated
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: test_payload
  states: {}
- name: zz_build_guard_and_impairment
  id: epy_block
  parameters:
    _source_code: |-
      from pathlib import Path

      import numpy as np
      from gnuradio import gr


      def _require_build(algorithm):
          supported = {'ls', 'lms', 'comb', 'sta', 'cnn'}
          if algorithm not in supported:
              raise RuntimeError(
                  f"unknown EQUALIZER_ALGORITHM={algorithm!r}; choose LS, LMS, COMB, STA, or CNN")
          build = Path('build')
          marker = build / 'frame_equalizer_build_mode.txt'
          artifacts = [build / 'final.xclbin', build / 'insts.bin']
          missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
          if missing:
              raise RuntimeError(
                  'missing frame-equalizer build output(s): ' + ', '.join(missing) +
                  '; run `make test-grc EQUALIZER_ALGORITHM=' + algorithm.upper() + '`')
          mode = {}
          for line in marker.read_text().splitlines():
              if '=' in line:
                  key, value = line.split('=', 1)
                  mode[key.strip()] = value.strip()
          if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '1':
              raise RuntimeError(
                  'NPU is not a symbols build (DFRAME_EQUALIZER_OUTPUT_SYMBOLS=' +
                  repr(mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS')) +
                  '); run `make test-grc EQUALIZER_ALGORITHM=' + algorithm.upper() + '`')
          if mode.get('EQUALIZER_ALGORITHM', '').lower() != algorithm:
              raise RuntimeError(
                  'NPU algorithm is ' + repr(mode.get('EQUALIZER_ALGORITHM', 'unknown')) +
                  ', but the flowgraph selected ' + repr(algorithm) +
                  '; rebuild through `make test-grc EQUALIZER_ALGORITHM=' +
                  algorithm.upper() + '`')
          if mode.get('ENGINE') not in {'CLASSIC', 'AI'}:
              raise RuntimeError('invalid or missing ENGINE in ' + str(marker))
          if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts):
              raise RuntimeError(
                  str(marker) + ' is older than the NPU artifacts; rebuild with `make test-grc`')
          instructions = np.fromfile(artifacts[1], dtype=np.uint32)
          for sentinel in (0x13579BDF, 0x2468ACE0):
              count = int(np.count_nonzero(instructions == sentinel))
              if count != 1:
                  raise RuntimeError(
                      f'build/insts.bin has {count} copies of RTP marker {sentinel:#x}; expected 1')


      def _profiles():
          flat = np.full((32, 64), 0.5, dtype=np.complex64)
          channel = np.zeros(64, dtype=np.complex128)
          occupied = [i for i in range(6, 59) if i != 32]
          channel[occupied] = np.linspace(9000, 21000, len(occupied)) / (1 << 15) * np.exp(
              1j * np.linspace(-0.45, 0.35, len(occupied)))
          cfo = round(0.002 * (1 << 29)) / float(1 << 29)
          bins = np.arange(64) - 32
          tracked = np.empty((11, 64), dtype=np.complex64)
          for number in range(11):
              ramp = cfo * 20 / 2417 * number * 80 * bins / 64
              tracked[number] = channel * np.exp(1j * (0.08 + 0.012*number - ramp))
          damaged = np.full((4, 64), 0.5, dtype=np.complex64)
          return np.concatenate((flat, tracked, damaged))


      class impairment_profile(gr.sync_block):
          """Emit deterministic per-bin channel/CFO coefficients for 47 OFDM vectors."""

          def __init__(self, algorithm='ls'):
              gr.sync_block.__init__(
                  self, name='impairment_profile', in_sig=None,
                  out_sig=[(np.complex64, 64)])
              self.algorithm = algorithm
              self.data = _profiles()
              self.position = 0

          def start(self):
              _require_build(self.algorithm)
              return True

          def work(self, input_items, output_items):
              if self.position == len(self.data):
                  return -1
              count = min(len(output_items[0]), len(self.data) - self.position)
              output_items[0][:count] = self.data[self.position:self.position + count]
              self.position += count
              return count
    algorithm: algorithm
    comment: '*epy: deterministic channel/CFO injection plus build validation.'
  states: {}

connections:
- [blocks_apply_impairment, '0', blocks_batch_mux, '1']
- [blocks_batch_mux, '0', virtual_sink_0_0, '0']
- [blocks_header_damage_source, '0', blocks_header_xor, '1']
- [blocks_header_payload_mux, '0', virtual_sink_0, '0']
- [blocks_header_xor, '0', digital_signal_bpsk, '0']
- [blocks_leading_padding_source, '0', blocks_batch_mux, '0']
- [blocks_payload_source, '0', digital_signal_header, '0']
- [blocks_payload_source, '0', ieee802_11_payload_symbols, '0']
- [blocks_stream_to_vector_npu, '0', blocks_npu_decisions_sink, '0']
- [blocks_trailing_padding_source, '0', blocks_batch_mux, '2']
- [blocks_vector_to_stream, '0', mlir_aie_frame_equalizer_npu, '0']
- [digital_carrier_allocator, '0', blocks_apply_impairment, '0']
- [digital_signal_bpsk, '0', blocks_header_payload_mux, '0']
- [digital_signal_header, '0', blocks_header_xor, '0']
- [ieee802_11_frame_equalizer_reference, '0', blocks_gnu_decisions_sink, '0']
- [ieee802_11_frame_equalizer_reference, symbols, blocks_symbols_debug, store]
- [ieee802_11_payload_symbols, '0', blocks_header_payload_mux, '1']
- [mlir_aie_frame_equalizer_npu, '0', blocks_stream_to_vector_npu, '0']
- [virtual_source_0, '0', digital_carrier_allocator, '0']
- [virtual_source_0_0, '0', blocks_vector_to_stream, '0']
- [virtual_source_0_0, '0', ieee802_11_frame_equalizer_reference, '0']
- [zz_build_guard_and_impairment, '0', blocks_apply_impairment, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
