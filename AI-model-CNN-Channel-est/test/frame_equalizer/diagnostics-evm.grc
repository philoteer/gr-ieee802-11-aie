options:
  parameters:
    category: Custom
    description: Run the standalone frame equalizer NPU kernel on recorded FFT output.
    generate_options: no_gui
    id: frame_equalizer_test
    output_language: python
    run_options: run
    title: Frame Equalizer Test
  states: {}

blocks:
- name: diagnostic_estimator
  id: variable
  parameters:
    comment: Label the XCLBIN estimator used for exported comparisons.
    value: '"LS"'
  states: {}
- name: diagnostic_evm_output
  id: variable
  parameters:
    comment: Bounded channel-estimator diagnostic export.
    value: '"../../data/tmp_out/channel_estimator_evm_unit_test.jsonl"'
  states: {}
- name: diagnostic_max_records
  id: variable
  parameters:
    comment: Maximum number of frame and CRC event records written to JSONL.
    value: '10000'
  states: {}
- name: diagnostic_output
  id: variable
  parameters:
    comment: Bounded channel-estimator diagnostic export.
    value: '"../../data/tmp_out/channel_estimator_diagnostic_unit_test.jsonl"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    comment: Recorded, scalarized complex output of the FFT block
    detached: 'True'
    file: /home/piloteer/바탕화면/fft_full.iqdata
    hdr_file: /home/piloteer/바탕화면/fft_full.iqdata.hdr
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import tempfile

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel


      N_TILES = 4
      FFT_MAX_TAGS = 31
      FFT_METADATA_WORDS = 2 + 2 * FFT_MAX_TAGS
      MAX_OUTPUT_TAGS = 16
      CSI_SIZE = 64
      Q16_15_SCALE = 1 << 15
      Q29_SCALE = 1 << 29

      CSI_DTYPE = np.dtype([
          ("real", np.int32),
          ("imag", np.int32),
      ], align=True)
      TAG_METADATA_DTYPE = np.dtype([
          ("offset", np.int32),
          ("frame_start", np.uint32),
          ("frame_bytes", np.uint64),
          ("encoding", np.uint64),
          ("snr_linear", np.uint64),
          ("center_frequency_mhz", np.uint32),
          ("frequency_offset", np.int32),
          ("beta", np.int32),
          ("csi", CSI_DTYPE, (CSI_SIZE,)),
      ], align=True)
      TILE_METADATA_DTYPE = np.dtype([
          ("output_length", np.int32),
          ("tag_count", np.int32),
          ("tags", TAG_METADATA_DTYPE, (MAX_OUTPUT_TAGS,)),
      ], align=True)
      OUTPUT_METADATA_WORDS = (
          N_TILES * TILE_METADATA_DTYPE.itemsize // np.dtype(np.int32).itemsize
      )


      class frame_equalizer_npu(gr.basic_block):
          """Adapt GNU Radio complex samples and tags to the frame equalizer ABI."""

          def __init__(self, path_xclbin="build/final.xclbin",
                       path_insts_bin="build/insts.bin", VECTOR_SIZE=4096, nominal_frequency=2.417e9):
              gr.basic_block.__init__(
                  self,
                  name="frame_equalizer_npu",
                  in_sig=[np.complex64],
                  out_sig=[np.int8],
              )

              if VECTOR_SIZE % N_TILES:
                  raise ValueError("VECTOR_SIZE must be divisible by four")
              if TAG_METADATA_DTYPE.itemsize != 560:
                  raise RuntimeError("frame equalizer tag metadata ABI mismatch")
              if TILE_METADATA_DTYPE.itemsize != 8968:
                  raise RuntimeError("frame equalizer tile metadata ABI mismatch")

              self.path_xclbin = path_xclbin
              self.path_insts_bin = path_insts_bin
              self.kernel_handle = None
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // N_TILES
              self.nominal_frequency = nominal_frequency
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=np.int8)
              self.out_meta_buf = iron.zeros(
                  OUTPUT_METADATA_WORDS, dtype=np.int32)

              self.set_output_multiple(VECTOR_SIZE)
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.wifi_start_key = pmt.intern("wifi_start")
              self.tag_srcid = pmt.intern("frame_equalizer")
              self.tag_keys = {
                  "frame_bytes": pmt.intern("frame bytes"),
                  "encoding": pmt.intern("encoding"),
                  "snr": pmt.intern("snr"),
                  "nominal_frequency": pmt.intern("nominal frequency"),
                  "frequency_offset": pmt.intern("frequency offset"),
                  "beta": pmt.intern("beta"),
                  "csi": pmt.intern("csi"),
              }

          def set_nominal_frequency(self, nominal_frequency):
              self.nominal_frequency = nominal_frequency

          def start(self):
              center_frequency_mhz = round(self.nominal_frequency / 1e6)
              instructions = np.fromfile(self.path_insts_bin, dtype=np.uint32).copy()
              for marker, value in (
                      (0x13579BDF, center_frequency_mhz),
                      (0x2468ACE0, round(20.0 / center_frequency_mhz * (1 << 30)))):
                  matches = np.flatnonzero(instructions == marker)
                  if len(matches) != 1:
                      raise RuntimeError("center-frequency RTP marker is missing or ambiguous")
                  instructions[matches[0]] = np.uint32(value)
              self.rtp_dir = tempfile.TemporaryDirectory()
              patched_insts = os.path.join(self.rtp_dir.name, "insts.bin")
              instructions.tofile(patched_insts)
              kernel = NPUKernel(
                  self.path_xclbin,
                  patched_insts,
                  kernel_name="MLIR_AIE",
              )
              self.kernel_handle = DefaultNPURuntime.load(kernel)
              return True

          def forecast(self, noutput_items, ninputs):
              return [max(self.VECTOR_SIZE, noutput_items)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_chunks = min(
                  len(in0) // self.VECTOR_SIZE,
                  len(out0) // self.VECTOR_SIZE,
              )
              if n_chunks == 0:
                  return 0

              abs_read_start = self.nitems_read(0)
              abs_write_start = self.nitems_written(0)
              total_produced = 0

              for chunk_idx in range(n_chunks):
                  chunk_start = chunk_idx * self.VECTOR_SIZE
                  chunk_end = chunk_start + self.VECTOR_SIZE
                  samples = in0[chunk_start:chunk_end]

                  # Embedded blocks cannot expose s64 ports. Convert complex64 to
                  # the kernel's interleaved Q16.15 cint32 representation here.
                  scaled_real = np.rint(samples.real * Q16_15_SCALE)
                  scaled_imag = np.rint(samples.imag * Q16_15_SCALE)
                  limits = np.iinfo(np.int32)
                  components = np.empty(self.VECTOR_SIZE * 2, dtype=np.int32)
                  components[0::2] = np.clip(
                      scaled_real, limits.min, limits.max).astype(np.int32)
                  components[1::2] = np.clip(
                      scaled_imag, limits.min, limits.max).astype(np.int32)

                  input_metadata = np.zeros(
                      (N_TILES, FFT_METADATA_WORDS), dtype=np.int32)
                  chunk_abs_start = abs_read_start + chunk_start
                  for tile_idx in range(N_TILES):
                      tile_abs_start = chunk_abs_start + tile_idx * self.TILE_SIZE
                      tile_abs_end = tile_abs_start + self.TILE_SIZE
                      tags = self.get_tags_in_range(
                          0, tile_abs_start, tile_abs_end, self.wifi_start_key)
                      tags = tags[:FFT_MAX_TAGS]
                      input_metadata[tile_idx, 0] = self.TILE_SIZE
                      input_metadata[tile_idx, 1] = len(tags)
                      for tag_idx, tag in enumerate(tags):
                          input_metadata[tile_idx, 2 + 2 * tag_idx] = (
                              int(tag.offset) - tile_abs_start)
                          value = pmt.to_double(tag.value)
                          input_metadata[tile_idx, 3 + 2 * tag_idx] = np.int32(
                              np.clip(round(value * Q29_SCALE),
                                      limits.min, limits.max))

                  DefaultNPURuntime.run(
                      self.kernel_handle,
                      [
                          iron.tensor(components, dtype=np.int32),
                          iron.tensor(input_metadata.reshape(-1), dtype=np.int32),
                          self.out_buf,
                          self.out_meta_buf,
                      ],
                  )

                  npu_output = self.out_buf.numpy()
                  metadata = self.out_meta_buf.numpy().view(
                      TILE_METADATA_DTYPE).reshape(N_TILES)
                  for tile_idx, tile_meta in enumerate(metadata):
                      tile_len = max(
                          0, min(int(tile_meta["output_length"]), self.TILE_SIZE))
                      tile_start = tile_idx * self.TILE_SIZE
                      output_start = total_produced
                      output_end = output_start + tile_len
                      out0[output_start:output_end] = npu_output[
                          tile_start:tile_start + tile_len]

                      tile_abs_start = abs_write_start + output_start
                      tag_count = max(
                          0, min(int(tile_meta["tag_count"]), MAX_OUTPUT_TAGS))
                      for tag in tile_meta["tags"][:tag_count]:
                          tag_offset = int(tag["offset"])
                          if 0 <= tag_offset < tile_len:
                              self._add_frame_tags(tile_abs_start + tag_offset, tag)
                      total_produced = output_end

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced

          def _add_frame_tags(self, offset, tag):
              csi = np.empty(CSI_SIZE, dtype=np.complex64)
              csi.real = tag["csi"]["real"] / Q16_15_SCALE
              csi.imag = tag["csi"]["imag"] / Q16_15_SCALE
              values = {
                  "frame_bytes": pmt.from_uint64(int(tag["frame_bytes"])),
                  "encoding": pmt.from_uint64(int(tag["encoding"])),
                  "snr": pmt.from_double(10.0 * np.log10(int(tag["snr_linear"]) / 32.0)),
                  "nominal_frequency": pmt.from_double(int(tag["center_frequency_mhz"]) * 1e6),
                  "frequency_offset": pmt.from_double(
                      int(tag["frequency_offset"]) / Q29_SCALE * 20e6 / (2.0 * np.pi)),
                  "beta": pmt.from_double(int(tag["beta"]) / Q29_SCALE),
                  "csi": pmt.init_c32vector(52, csi[:52].tolist()),
              }
              for name, value in values.items():
                  self.add_item_tag(
                      0, offset, self.tag_keys[name], value, self.tag_srcid)
    comment: Converts complex64 to cint32 internally because Embedded Python blocks do not support s64 ports.
    nominal_frequency: freq
    path_insts_bin: '"build/insts.bin"'
    path_xclbin: '"build/final.xclbin"'
  states: {state: disabled}
- name: epy_evm_diagnostic
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      class evm_diagnostic(gr.basic_block):
          def __init__(self, output_path='../../data/tmp_out/channel_estimator_evm.jsonl',
                       max_records=10000, report_interval=25, estimator_label='LS'):
              gr.basic_block.__init__(
                  self,
                  name='evm_diagnostic',
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.output_file = None
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.record_count = 0
              self.evm_samples = 0
              self.error_power_sum = 0.0
              self.reference_power_sum = 0.0
              self.aligned_evm_sum = 0.0
              self.output_lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_iq_data)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              if output_path:
                  self.output_file = open(output_path, 'w', encoding='ascii')

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              if len(input_items[0]):
                  self.consume(0, len(input_items[0]))
              return 0

          def _write_record(self, record):
              with self.output_lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(
                      json.dumps(record, separators=(',', ':'), allow_nan=False) + '\n'
                  )
                  self.output_file.flush()
                  self.record_count += 1

          @staticmethod
          def _metadata_uint64(metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _handle_iq_data(self, message):
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'expected_metadata_and_iq_dictionary',
                  })
                  return

              metadata = pmt.car(message)
              iq_data = pmt.cdr(message)
              vectors = {}
              for key in ('transmitted_iq', 'equalized_iq'):
                  value = pmt.dict_ref(iq_data, pmt.intern(key), pmt.PMT_NIL)
                  if not pmt.is_c32vector(value):
                      self._write_record({
                          'event': 'invalid_evm_message',
                          'reason': 'missing_complex_vector',
                          'vector': key,
                      })
                      return
                  vectors[key] = np.asarray(
                      pmt.c32vector_elements(value), dtype=np.complex128
                  )

              transmitted = vectors['transmitted_iq']
              equalized = vectors['equalized_iq']
              if (transmitted.size == 0 or transmitted.size % 48 != 0 or
                            equalized.size != transmitted.size or
                      not np.all(np.isfinite(transmitted)) or
                      not np.all(np.isfinite(equalized))):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'invalid_vector_size_or_nonfinite_values',
                      'transmitted_iq_size': int(transmitted.size),
                      'received_iq_size': None,
                      'equalized_iq_size': int(equalized.size),
                  })
                  return

              reference_power = float(np.vdot(transmitted, transmitted).real)
              if reference_power <= np.finfo(np.float64).tiny:
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'zero_reference_power',
                  })
                  return

              error = equalized - transmitted
              error_power = float(np.vdot(error, error).real)
              evm_ratio = float(np.sqrt(error_power / reference_power))
              gain = np.vdot(transmitted, equalized) / reference_power
              aligned_error = equalized / gain - transmitted if abs(gain) else error
              aligned_evm_ratio = float(np.sqrt(
                  np.vdot(aligned_error, aligned_error).real / reference_power
              ))
              evm_percent = 100.0 * evm_ratio
              aligned_evm_percent = 100.0 * aligned_evm_ratio
              evm_db = float(20.0 * np.log10(max(evm_ratio, 1e-15)))
              frame_bytes = self._metadata_uint64(metadata, 'frame bytes')
              encoding = self._metadata_uint64(metadata, 'encoding')

              self.evm_samples += 1
              self.error_power_sum += error_power
              self.reference_power_sum += reference_power
              self.aligned_evm_sum += aligned_evm_percent
              cumulative_evm_percent = float(100.0 * np.sqrt(
                  self.error_power_sum / self.reference_power_sum
              ))
              mean_aligned_evm_percent = self.aligned_evm_sum / self.evm_samples
              self._write_record({
                  'event': 'evm',
                  'sample_index': self.evm_samples,
                  'frame_bytes': frame_bytes,
                  'encoding': encoding,
                  'payload_symbols_compared': int(transmitted.size // 48),
                  'complex_symbols_compared': int(transmitted.size),
                  'evm_rms_percent': evm_percent,
                  'evm_rms_db': evm_db,
                  'mer_db': -evm_db,
                  'gain_magnitude_db': 20.0 * np.log10(max(abs(gain), 1e-15)),
                  'gain_phase_deg': float(np.degrees(np.angle(gain))),
                  'gain_aligned_evm_rms_percent': aligned_evm_percent,
                  'cumulative_evm_rms_percent': cumulative_evm_percent,
                  'mean_gain_aligned_evm_percent': mean_aligned_evm_percent,
                  'region': 'CRC-valid equalized payload symbols, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              if self.evm_samples == 1 or self.evm_samples % self.report_interval == 0:
                  print(
                      'EVM: sample={} encoding={} symbols={} raw={:.4f}% aligned={:.4f}% cumulative={:.4f}%'.format(
                          self.evm_samples, encoding, transmitted.size // 48,
                          evm_percent, aligned_evm_percent, cumulative_evm_percent
                      )
                  )

          def stop(self):
              if self.output_file is not None:
                  self.output_file.close()
                  self.output_file = None
              return True
    estimator_label: diagnostic_estimator
    max_records: diagnostic_max_records
    output_path: diagnostic_evm_output
    report_interval: '25'
  states: {}
- name: epy_frame_diagnostic
  id: epy_block
  parameters:
    _source_code: |
      import json
      import os
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class frame_diagnostic(gr.basic_block):
          def __init__(self, output_path='../../data/tmp_out/frame_diagnostic.jsonl',
                       max_records=10000, report_interval=25,
                       headless_idle_seconds=10.0, estimator_label='LS'):
              gr.basic_block.__init__(
                  self,
                  name='frame_diagnostic',
                  in_sig=[np.int8],
                  out_sig=[np.float32, np.float32, np.float32],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.record_count = 0
              self.crc_valid_count = 0
              self.pre_fec_bit_errors = 0
              self.pre_fec_bits_compared = 0
              self.pre_fec_ber_samples = 0
              self.latest_ber = 0.0
              self.cumulative_ber = 0.0
              self.pending = []
              self.lock = threading.Lock()
              self.last_work = time.monotonic()
              self.seen_input = False
              self.stopping = False
              self.message_port_register_in(pmt.intern('crc_ok'))
              self.set_msg_handler(pmt.intern('crc_ok'), self._handle_crc_ok)
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_diag)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              self.output_file = open(output_path, 'w', encoding='ascii') if output_path else None

              if os.environ.get('WIFI_DIAGNOSTIC_HEADLESS') == '1':
                  self.headless_thread = threading.Thread(
                      target=self._headless_watchdog,
                      args=(max(1.0, float(headless_idle_seconds)),),
                      daemon=True,
                  )
                  self.headless_thread.start()

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              if len(input_items[0]):
                  self.seen_input = True
                  self.last_work = time.monotonic()
                  self.consume(0, len(input_items[0]))
              with self.lock:
                  produced = min(len(self.pending), *(len(items) for items in output_items))
                  for index in range(produced):
                      values = self.pending.pop(0)
                      for port, value in enumerate(values):
                          output_items[port][index] = value
              return produced

          def _write_record(self, record):
              with self.lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(
                      json.dumps(record, separators=(',', ':'), allow_nan=False) + '\n'
                  )
                  self.output_file.flush()
                  self.record_count += 1

          def _queue_metrics(self):
              with self.lock:
                  self.pending.append((
                      float(self.crc_valid_count),
                      self.latest_ber,
                      self.cumulative_ber,
                  ))

          def _handle_crc_ok(self, _message):
              with self.lock:
                  self.crc_valid_count += 1
                  crc_valid_count = self.crc_valid_count
              self._write_record({
                  'event': 'crc_ok',
                  'crc_valid_count': crc_valid_count,
                  'estimator': self.estimator_label,
              })
              self._queue_metrics()

          @staticmethod
          def _metadata_uint64(metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _handle_diag(self, message):
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  return
              metadata = pmt.car(message)
              diagnostic = pmt.cdr(message)
              received = pmt.dict_ref(diagnostic, pmt.intern('pre_viterbi'), pmt.PMT_NIL)
              corrected = pmt.dict_ref(diagnostic, pmt.intern('corrected_coded'), pmt.PMT_NIL)
              if not pmt.is_u8vector(received) or not pmt.is_u8vector(corrected):
                  return
              rx_bits = np.asarray(pmt.u8vector_elements(received), dtype=np.uint8)
              reference_bits = np.asarray(pmt.u8vector_elements(corrected), dtype=np.uint8)
              if (rx_bits.size == 0 or rx_bits.size != reference_bits.size or
                      np.any(rx_bits > 1) or np.any(reference_bits > 1)):
                  return

              bit_errors = int(np.count_nonzero(rx_bits != reference_bits))
              bits_compared = int(rx_bits.size)
              sample_ber = bit_errors / bits_compared
              with self.lock:
                  self.pre_fec_ber_samples += 1
                  self.pre_fec_bit_errors += bit_errors
                  self.pre_fec_bits_compared += bits_compared
                  self.latest_ber = sample_ber
                  self.cumulative_ber = self.pre_fec_bit_errors / self.pre_fec_bits_compared
                  sample_index = self.pre_fec_ber_samples
                  cumulative_ber = self.cumulative_ber
              self._write_record({
                  'event': 'pre_fec_coded_ber',
                  'sample_index': sample_index,
                  'frame_bytes': self._metadata_uint64(metadata, 'frame bytes'),
                  'encoding': self._metadata_uint64(metadata, 'encoding'),
                  'bit_errors': bit_errors,
                  'bits_compared': bits_compared,
                  'ber': sample_ber,
                  'cumulative_bit_errors': self.pre_fec_bit_errors,
                  'cumulative_bits_compared': self.pre_fec_bits_compared,
                  'cumulative_ber': cumulative_ber,
                  'region': 'deinterleaved coded bits, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              self._queue_metrics()
              if sample_index == 1 or sample_index % self.report_interval == 0:
                  print('pre-FEC coded BER sample {}: {}/{} ({:.6g}); cumulative {:.6g}'.format(
                      sample_index, bit_errors, bits_compared, sample_ber, cumulative_ber
                  ))

          def _headless_watchdog(self, idle_seconds):
              while not self.stopping:
                  time.sleep(0.25)
                  if self.seen_input and time.monotonic() - self.last_work >= idle_seconds:
                      try:
                          from PyQt5 import QtWidgets
                          app = QtWidgets.QApplication.instance()
                          if app is not None:
                              app.quit()
                      except ImportError:
                          pass
                      return

          def stop(self):
              self.stopping = True
              if self.output_file is not None:
                  self.output_file.close()
                  self.output_file = None
              return True
    estimator_label: diagnostic_estimator
    headless_idle_seconds: '10.0'
    max_records: diagnostic_max_records
    output_path: diagnostic_output
    report_interval: '25'
  states: {}
- name: evm_build_mode_check
  id: snippet
  parameters:
    code: |-
      from pathlib import Path

      build = Path('build')
      marker = build / 'frame_equalizer_build_mode.txt'
      artifacts = [build / 'final.xclbin', build / 'insts.bin']
      missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
      if missing: raise RuntimeError('EVM diagnostics require kernel build output(s): ' + ', '.join(missing) + '; run `make DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile` from stage42/test/frame_equalizer/')
      mode = dict((parts[0].strip(), parts[1].strip()) for parts in (line.split('=', 1) for line in marker.read_text(encoding='ascii').splitlines()) if len(parts) == 2)
      if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '1': raise RuntimeError('EVM diagnostics require DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1; rebuild with `make DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile` from stage42/test/frame_equalizer/')
      if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts): raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild the kernel')
    section: init_before_blocks
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_equalizer_test_evm_0
  id: mlir_aie_mlir_aie_cpp_equalizer_test_evm
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
    weights_path: ''''''
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: out
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: diag
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: out
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: diag
  states: {}

connections:
- [blocks_file_meta_source_0, '0', epy_block_0, '0']
- [blocks_file_meta_source_0, '0', mlir_aie_mlir_aie_cpp_equalizer_test_evm_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [epy_frame_diagnostic, '0', blocks_null_sink_0, '0']
- [epy_frame_diagnostic, '1', blocks_null_sink_0, '1']
- [epy_frame_diagnostic, '2', blocks_null_sink_0, '2']
- [ieee802_11_decode_mac_EVM_0, diag, virtual_sink_1_0_0, '0']
- [ieee802_11_decode_mac_EVM_0, out, virtual_sink_1_0, '0']
- [mlir_aie_mlir_aie_cpp_equalizer_test_evm_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_mlir_aie_cpp_equalizer_test_evm_0, '0', virtual_sink_1, '0']
- [virtual_source_1, '0', epy_evm_diagnostic, '0']
- [virtual_source_1, '0', epy_frame_diagnostic, '0']
- [virtual_source_1_0, '0', epy_frame_diagnostic, crc_ok]
- [virtual_source_1_0_0, '0', epy_evm_diagnostic, diag]
- [virtual_source_1_0_0, '0', epy_frame_diagnostic, diag]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
