options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: sync_long_results_viewer
    output_language: python
    run_options: run
    title: Sync Long Results Viewer
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: ../../data/tmp_out/_original.iqdata
    hdr_file: ../../data/tmp_out/_original.iqdata.hdr
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_meta_source_0_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: ../../data/tmp_out/_npu.iqdata
    hdr_file: ../../data/tmp_out/_npu.iqdata.hdr
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_meta_source_0_1
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: ../../data/tmp_out/__npu.iqdata
    hdr_file: ../../data/tmp_out/__npu.iqdata.hdr
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 1e6
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_meta_source_0, '0', blocks_throttle2_0, '0']
- [blocks_file_meta_source_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_file_meta_source_0_1, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
