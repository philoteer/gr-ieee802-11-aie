options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../data/tmp_out/_original.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../data/tmp_out/_npu.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../../data/raw_capture/output_head_short.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import blocks, gr, gr_unittest

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel

      class npu_sync_short(gr.basic_block):
          VECTOR_SIZE = 4096
          TILE_SIZE = VECTOR_SIZE // 4
          DELAY_SAMPLES = 320
          MAX_TAGS = 7
          METADATA_WORDS = 2 + 2 * MAX_TAGS
          THRESHOLD = 0.56
          THRESHOLD_WORDS = (TILE_SIZE + 3) // 4
          IN_TILE_WORDS = 3 * TILE_SIZE + THRESHOLD_WORDS
          OUT_TILE_WORDS = TILE_SIZE + DELAY_SAMPLES + METADATA_WORDS

          def __init__(self, xclbin="build/final.xclbin", insts="build/insts.bin"):
              gr.basic_block.__init__(
                  self,
                  name="npu_sync_short",
                  in_sig=[np.complex64, np.complex64, np.float32],
                  out_sig=[np.complex64],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.set_output_multiple(self.VECTOR_SIZE)

              kernel = NPUKernel(xclbin, insts, kernel_name="MLIR_AIE")
              self.kernel_handle = DefaultNPURuntime.load(kernel)
              self.out_buf = iron.zeros(4 * self.OUT_TILE_WORDS, dtype=np.int32)
              self.tag_key = pmt.intern("wifi_start")
              self.tag_srcid = pmt.intern("sync_short")

          def forecast(self, noutput_items, ninputs):
              return [max(self.VECTOR_SIZE, noutput_items)] * ninputs

          @staticmethod
          def _cint16(values):
              components = np.empty(2 * len(values), dtype=np.int16)
              scaled = np.rint(
                  np.clip(
                      np.column_stack((values.real, values.imag)), -1.0, 1.0
                  )
                  * 32768.0
              )
              components[:] = np.clip(scaled, -32768, 32767).astype(np.int16).reshape(-1)
              return components.view(np.int32)

          @staticmethod
          def _cint32_q24(values):
              scaled = np.rint(
                  np.column_stack((values.real, values.imag)) * float(1 << 24)
              )
              return np.clip(scaled, -(1 << 31), (1 << 31) - 1).astype(np.int32).reshape(-1)

          def _pack_tile(self, samples, abs_values, correlations):
              packed = np.zeros(self.IN_TILE_WORDS, dtype=np.int32)
              packed[: self.TILE_SIZE] = self._cint16(samples)
              packed[self.TILE_SIZE : 3 * self.TILE_SIZE] = self._cint32_q24(abs_values)
              threshold_bytes = packed[3 * self.TILE_SIZE :].view(np.int8)
              threshold_bytes[: self.TILE_SIZE] = correlations.astype(np.float64) > self.THRESHOLD
              return packed

          def general_work(self, input_items, output_items):
              available = min(len(stream) for stream in input_items)
              n_chunks = min(available // self.VECTOR_SIZE, len(output_items[0]) // self.VECTOR_SIZE)
              if n_chunks == 0:
                  return 0

              produced = 0
              output_abs_start = self.nitems_written(0)
              for chunk in range(n_chunks):
                  chunk_start = chunk * self.VECTOR_SIZE
                  packed_in = np.empty(4 * self.IN_TILE_WORDS, dtype=np.int32)
                  for tile in range(4):
                      src = chunk_start + tile * self.TILE_SIZE
                      dst = tile * self.IN_TILE_WORDS
                      packed_in[dst : dst + self.IN_TILE_WORDS] = self._pack_tile(
                          input_items[0][src : src + self.TILE_SIZE],
                          input_items[1][src : src + self.TILE_SIZE],
                          input_items[2][src : src + self.TILE_SIZE],
                      )

                  in_tensor = iron.tensor(packed_in, dtype=np.int32)
                  DefaultNPURuntime.run(self.kernel_handle, [in_tensor, self.out_buf])
                  packed_out = self.out_buf.numpy()

                  for tile in range(4):
                      tile_base = tile * self.OUT_TILE_WORDS
                      meta_base = tile_base + self.TILE_SIZE + self.DELAY_SAMPLES
                      metadata = packed_out[meta_base : meta_base + self.METADATA_WORDS]
                      tile_len = max(0, min(int(metadata[0]), self.TILE_SIZE))
                      tag_count = max(0, min(int(metadata[1]), self.MAX_TAGS))

                      data_start = tile_base + self.DELAY_SAMPLES
                      data = packed_out[data_start : data_start + tile_len]
                      components = data.view(np.int16).reshape(-1, 2).astype(np.float32)
                      next_produced = produced + tile_len
                      output_items[0][produced:next_produced] = (
                          components[:, 0] + 1j * components[:, 1]
                      ) * (1.0 / 32768.0)

                      for tag in range(tag_count):
                          offset = int(metadata[2 + 2 * tag])
                          if 0 <= offset < tile_len:
                              value = float(metadata[3 + 2 * tag]) / (1 << 29)
                              self.add_item_tag(
                                  0,
                                  output_abs_start + produced + offset,
                                  self.tag_key,
                                  pmt.from_double(value),
                                  self.tag_srcid,
                              )
                      produced = next_produced

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return produced
    insts: '"build/insts.bin"'
    minoutbuf: '4096'
    xclbin: '"build/final.xclbin"'
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', epy_block_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', epy_block_0, '2']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', epy_block_0, '1']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [epy_block_0, '0', blocks_file_meta_sink_0_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_file_meta_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
