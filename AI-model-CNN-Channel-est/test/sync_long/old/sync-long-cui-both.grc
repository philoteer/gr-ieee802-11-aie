options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: sync_long_test
    output_language: python
    run_options: run
    title: Sync Long Test
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../../data/tmp_out/_npu.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_meta_sink_0_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ../../../data/tmp_out/_original.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../../../data/raw_capture/wifi_iq_hackrf.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-

      import numpy as np
      from gnuradio import gr
      import pmt

      import aie.iron as iron
      from aie.utils import NPUKernel, DefaultNPURuntime

      DTYPE_IN = np.int32
      DTYPE_OUT = np.int32


      class mlir_aie_python_int32(gr.basic_block):
          """
          GNU Radio wrapper for the standalone sync_long_cf test kernel.
          """

          def __init__(self, path_xclbin="build/final.xclbin", path_insts_bin="build/insts.bin", VECTOR_SIZE=4096):
              gr.basic_block.__init__(
                  self,
                  name="mlir_aie_python_int32",
                  in_sig=[DTYPE_IN],
                  out_sig=[DTYPE_OUT],
              )

              npu_kernel = NPUKernel(path_xclbin, path_insts_bin, kernel_name="MLIR_AIE")
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.kernel_handle = DefaultNPURuntime.load(npu_kernel)

              self.MAX_TAGS_PER_TILE = 7
              self.METADATA_WORDS_PER_TILE = 2 + 2 * self.MAX_TAGS_PER_TILE
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // 4
              self.DELAY_SAMPLES = 320
              self.IN_TILE_SIZE = self.TILE_SIZE + self.DELAY_SAMPLES
              self.IN_VECTOR_SIZE = self.IN_TILE_SIZE * 4

              self.out_buf = iron.zeros(self.VECTOR_SIZE, dtype=DTYPE_OUT)
              self.out_meta_buf = iron.zeros(4 * self.METADATA_WORDS_PER_TILE, dtype=np.int32)
              self.delay_history = np.zeros(self.DELAY_SAMPLES, dtype=DTYPE_IN)

              self.set_output_multiple(self.VECTOR_SIZE)

              self.tag_key = pmt.intern("wifi_start")
              self.tag_srcid = pmt.intern("sync_short")

          def forecast(self, noutput_items, ninputs):
              return [max(self.VECTOR_SIZE, noutput_items)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              n_chunks = min(len(in0) // self.VECTOR_SIZE, len(out0) // self.VECTOR_SIZE)
              if n_chunks == 0:
                  return 0

              total_produced = 0
              abs_read_start = self.nitems_read(0)
              output_abs_start = self.nitems_written(0)

              for chunk_idx in range(n_chunks):
                  chunk_start = chunk_idx * self.VECTOR_SIZE
                  chunk_abs_start = abs_read_start + chunk_start
                  in_np = np.zeros(self.IN_VECTOR_SIZE, dtype=DTYPE_IN)
                  in_meta_np = np.zeros((4, self.METADATA_WORDS_PER_TILE), dtype=np.int32)

                  for tile_idx in range(4):
                      src_start = chunk_start + tile_idx * self.TILE_SIZE
                      src_end = src_start + self.TILE_SIZE
                      dst_start = tile_idx * self.IN_TILE_SIZE + self.DELAY_SAMPLES
                      dst_end = dst_start + self.TILE_SIZE
                      in_np[dst_start - self.DELAY_SAMPLES:dst_start] = self.delay_history
                      in_np[dst_start:dst_end] = in0[src_start:src_end]
                      self.delay_history[:] = in0[src_end - self.DELAY_SAMPLES:src_end]

                      tile_abs_start = chunk_abs_start + tile_idx * self.TILE_SIZE
                      tile_abs_end = tile_abs_start + self.TILE_SIZE
                      tags = self.get_tags_in_range(0, tile_abs_start, tile_abs_end, self.tag_key)
                      tag_count = min(len(tags), self.MAX_TAGS_PER_TILE)
                      in_meta_np[tile_idx, 0] = self.TILE_SIZE
                      in_meta_np[tile_idx, 1] = tag_count
                      for tag_idx, tag in enumerate(tags[:tag_count]):
                          tag_offset = int(tag.offset - tile_abs_start)
                          tag_value = pmt.to_double(tag.value)
                          tag_value_q29 = np.int32(np.clip(round(tag_value * (1 << 29)), -(1 << 31), (1 << 31) - 1))
                          in_meta_np[tile_idx, 2 + 2 * tag_idx] = tag_offset
                          in_meta_np[tile_idx, 3 + 2 * tag_idx] = tag_value_q29

                  current_in_tensor = iron.tensor(in_np, dtype=DTYPE_IN)
                  current_in_meta_tensor = iron.tensor(in_meta_np.reshape(-1), dtype=np.int32)
                  DefaultNPURuntime.run(self.kernel_handle, [current_in_tensor, current_in_meta_tensor, self.out_buf, self.out_meta_buf])

                  out_np = self.out_buf.numpy()
                  out_meta = self.out_meta_buf.numpy().reshape(4, self.METADATA_WORDS_PER_TILE)
                  for tile_idx, tile_meta in enumerate(out_meta):
                      tile_len = max(0, min(int(tile_meta[0]), self.TILE_SIZE))
                      tag_count = max(0, min(int(tile_meta[1]), self.MAX_TAGS_PER_TILE))
                      tile_start = tile_idx * self.TILE_SIZE
                      tile_end = tile_start + tile_len
                      next_total_produced = total_produced + tile_len
                      out0[total_produced:next_total_produced] = out_np[tile_start:tile_end]

                      tile_abs_start = output_abs_start + total_produced
                      for tag_idx in range(tag_count):
                          tag_offset = int(tile_meta[2 + 2 * tag_idx])
                          tag_value = float(tile_meta[3 + 2 * tag_idx]) / (1 << 29)
                          if 0 <= tag_offset < tile_len:
                              self.add_item_tag(0, tile_abs_start + tag_offset, self.tag_key, pmt.from_double(tag_value), self.tag_srcid)

                      total_produced = next_total_produced

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced
    path_insts_bin: '"build/insts.bin"'
    path_xclbin: '"build/final.xclbin"'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: mlir_aie_cint16_to_complex64_0
  id: mlir_aie_cint16_to_complex64
  parameters: {}
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [epy_block_0, '0', mlir_aie_cint16_to_complex64_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_file_meta_sink_0_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [ieee802_11_sync_short_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [mlir_aie_cint16_to_complex64_0, '0', blocks_file_meta_sink_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
