options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.412e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ../../data/tmp_out/test_out
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../../data/raw_capture/output_head_short.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: 0.56 * 0.56
    init: '0'
    low: 0.56 * 0.56
  states: {}
- name: mlir_aie_complex64_to_cint32_0
  id: mlir_aie_complex64_to_cint32
  parameters:
    fractional_bits: '24'
    integer_bits: '7'
    safe: 'False'
  states: {}
- name: mlir_aie_float32_to_int32_Q_0
  id: mlir_aie_float32_to_int32_Q
  parameters:
    fractional_bits: '23'
    integer_bits: '8'
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0
  id: mlir_aie_mlir_aie_cpp_80211_magsq_and_div
  parameters:
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_0, '0', mlir_aie_float32_to_int32_Q_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', mlir_aie_complex64_to_cint32_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_multiply_xx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_sub_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_threshold_ff_0, '0', blocks_sub_xx_0, '1']
- [mlir_aie_complex64_to_cint32_0, '0', mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '0']
- [mlir_aie_float32_to_int32_Q_0, '0', mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '1']
- [mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '0', blocks_char_to_float_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
