options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2417000000.0'
  states: {}
- name: gain_BB
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '2'
    stop: '62'
    value: '0'
  states: {}
- name: gain_IF
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: gain_RF
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '14'
    stop: '14'
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: data/tmp_out/phy_full.iqdata
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_meta_source_0
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: data/phy_full.iqdata
    hdr_file: data/phy_full.iqdata.hdr
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/tmp_out/orig.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: data/raw_capture/stress_test.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      #
      # Copyright 2026 gr-mlir_aie author.
      #
      # SPDX-License-Identifier: GPL-3.0-or-later
      #


      import numpy as np
      from gnuradio import gr
      import pmt

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel
      import os
      import tempfile


      INPUT_DTYPE = np.int32
      OUTPUT_DTYPE = np.int8
      METADATA_DTYPE = np.int32

      MAX_TAGS_PER_TILE = 16
      N_TILES = 4
      CSI_SIZE = 64
      Q16_15_SCALE = 1.0 / (1 << 15)

      # These aligned dtypes reproduce tag_metadata and tile_metadata from the C++
      # block, including the uint64 fields and the CSI complex pairs.
      CSI_DTYPE = np.dtype([
          ("real", np.int32),
          ("imag", np.int32),
      ], align=True)
      TAG_METADATA_DTYPE = np.dtype([
          ("offset", np.int32),
          ("frame_start", np.uint32),
          ("frame_bytes", np.uint64),
          ("encoding", np.uint64),
          ("snr_linear", np.uint64),
          ("center_frequency_mhz", np.uint32),
          ("frequency_offset", np.int32),
          ("beta", np.int32),
          ("csi", CSI_DTYPE, (CSI_SIZE,)),
      ], align=True)
      TILE_METADATA_DTYPE = np.dtype([
          ("output_length", np.int32),
          ("tag_count", np.int32),
          ("tags", TAG_METADATA_DTYPE, (MAX_TAGS_PER_TILE,)),
      ], align=True)
      METADATA_WORDS = N_TILES * TILE_METADATA_DTYPE.itemsize // np.dtype(
          METADATA_DTYPE).itemsize


      class mlir_aie_python_80211_phy(gr.basic_block):
          """Run the MLIR-AIE 802.11 PHY and recreate frame equalizer tags."""

          def __init__(self,
                       path_xclbin="kernel/build/final.xclbin",
                       path_insts_bin="kernel/build/insts.bin",
                       kernel_name="MLIR_AIE",
                       VECTOR_SIZE=4096,
                       nominal_frequency=2.417e9):
              gr.basic_block.__init__(
                  self,
                  name="mlir_aie_python_80211_phy",
                  in_sig=[INPUT_DTYPE],
                  out_sig=[OUTPUT_DTYPE],
              )

              center_frequency_mhz = round(nominal_frequency / 1e6)
              instructions = np.fromfile(path_insts_bin, dtype=np.uint32).copy()
              for marker, value in ((0x13579BDF, center_frequency_mhz), (0x2468ACE0, round(20.0 / center_frequency_mhz * (1 << 30)))):
                  matches = np.flatnonzero(instructions == marker)
                  if len(matches) != 1:
                      raise RuntimeError("center-frequency RTP marker is missing or ambiguous")
                  instructions[matches[0]] = np.uint32(value)
              self.rtp_dir = tempfile.TemporaryDirectory()
              patched_insts = os.path.join(self.rtp_dir.name, "insts.bin")
              instructions.tofile(patched_insts)

              npu_kernel = NPUKernel(
                  path_xclbin,
                  patched_insts,
                  kernel_name=kernel_name,
              )
              self.kernel_handle = DefaultNPURuntime.load(npu_kernel)
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=OUTPUT_DTYPE)
              self.out_meta_buf = iron.zeros(METADATA_WORDS, dtype=METADATA_DTYPE)
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // N_TILES
              self.nominal_frequency = nominal_frequency

              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.tag_srcid = pmt.intern("frame_equalizer")
              self.tag_keys = {
                  "frame_bytes": pmt.intern("frame bytes"),
                  "encoding": pmt.intern("encoding"),
                  "snr": pmt.intern("snr"),
                  "nominal_frequency": pmt.intern("nominal frequency"),
                  "frequency_offset": pmt.intern("frequency offset"),
                  "beta": pmt.intern("beta"),
                  "csi": pmt.intern("csi"),
              }

          def forecast(self, noutput_items, ninputs):
              return [noutput_items] * ninputs

          def set_nominal_frequency(self, nominal_frequency):
              self.nominal_frequency = nominal_frequency

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_chunks = min(len(in0), len(out0)) // self.VECTOR_SIZE

              if n_chunks == 0:
                  return 0

              output_abs_start = self.nitems_written(0)
              total_produced = 0

              for chunk_idx in range(n_chunks):
                  input_start = chunk_idx * self.VECTOR_SIZE
                  input_end = input_start + self.VECTOR_SIZE
                  current_in_tensor = iron.tensor(
                      in0[input_start:input_end], dtype=INPUT_DTYPE)

                  DefaultNPURuntime.run(
                      self.kernel_handle,
                      [current_in_tensor, self.out_buf, self.out_meta_buf],
                  )

                  npu_output = self.out_buf.numpy()
                  metadata = self.out_meta_buf.numpy().view(
                      TILE_METADATA_DTYPE).reshape(N_TILES)

                  for tile_idx, tile_meta in enumerate(metadata):
                      tile_len = max(
                          0, min(int(tile_meta["output_length"]), self.TILE_SIZE))
                      tile_start = tile_idx * self.TILE_SIZE
                      out0[total_produced:total_produced + tile_len] = npu_output[
                          tile_start:tile_start + tile_len]

                      tile_abs_start = output_abs_start + total_produced
                      tag_count = max(
                          0, min(int(tile_meta["tag_count"]), MAX_TAGS_PER_TILE))
                      for tag in tile_meta["tags"][:tag_count]:
                          tag_offset = int(tag["offset"])
                          if 0 <= tag_offset < tile_len:
                              self._add_frame_tags(tile_abs_start + tag_offset, tag)

                      total_produced += tile_len

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced

          def _add_frame_tags(self, offset, tag):
              csi = np.empty(CSI_SIZE, dtype=np.complex64)
              csi.real = tag["csi"]["real"] * Q16_15_SCALE
              csi.imag = tag["csi"]["imag"] * Q16_15_SCALE

              values = {
                  "frame_bytes": pmt.from_uint64(int(tag["frame_bytes"])),
                  "encoding": pmt.from_uint64(int(tag["encoding"])),
                  "snr": pmt.from_double(10.0 * np.log10(int(tag["snr_linear"]) / 32.0)),
                  "nominal_frequency": pmt.from_double(int(tag["center_frequency_mhz"]) * 1e6),
                  "frequency_offset": pmt.from_double(
                      int(tag["frequency_offset"]) / (1 << 29) * 20e6 / (2.0 * np.pi)),
                  "beta": pmt.from_double(int(tag["beta"]) / (1 << 29)),
                  "csi": pmt.init_c32vector(52, csi[:52].tolist()),
              }
              for name, value in values.items():
                  self.add_item_tag(
                      0, offset, self.tag_keys[name], value, self.tag_srcid)
    kernel_name: '"MLIR_AIE"'
    nominal_frequency: freq
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain_BB
    bw0: samp_rate
    freq0: freq
    gain0: gain_RF
    gain_mode0: 'False'
    if_gain0: gain_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: 1_I
    label2: 1_Q
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_meta_source_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [epy_block_0, '0', blocks_file_meta_sink_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', epy_block_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_char_to_float_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_file_meta_sink_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
