options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: GNU Radio L-LTF channel-estimator dataset generator.
    generate_options: no_gui
    id: data
    output_language: python
    run_options: run
    title: Channel Estimator GNU Radio Dataset
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    comment: Target frequency-domain L-LTF amplitude.
    value: float(__import__('os').environ.get('DATASET_AMPLITUDE', '16000'))
  states: {}
- name: long_symbol
  id: variable
  parameters:
    comment: Standard shifted 64-bin IEEE 802.11 L-LTF sequence.
    value: (0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0)
  states: {}
- name: noise_amplitude
  id: variable
  parameters:
    comment: Complex AWGN amplitude giving the requested FFT-domain SNR.
    value: amplitude/(10.0**(snr_db/20.0))
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: NPZ path consumed by the offline corpus generator.
    value: __import__('os').environ.get('DATASET_OUTPUT', 'artifacts/gnuradio-dataset.npz')
  states: {}
- name: samples
  id: variable
  parameters:
    comment: Number of independent noisy L-LTF pairs.
    value: int(__import__('os').environ.get('DATASET_SAMPLES', '128'))
  states: {}
- name: seed
  id: variable
  parameters:
    comment: Seed for fading and the two independent AWGN sources.
    value: int(__import__('os').environ.get('DATASET_SEED', '41'))
  states: {}
- name: snr_db
  id: variable
  parameters:
    comment: Frequency-domain signal-to-noise ratio in dB.
    value: float(__import__('os').environ.get('DATASET_SNR_DB', '20'))
  states: {}
- name: add_first_noise
  id: blocks_add_xx
  parameters:
    comment: Form the first noisy L-LTF observation.
    type: complex
  states: {}
- name: add_second_noise
  id: blocks_add_xx
  parameters:
    comment: Form the second noisy L-LTF observation.
    type: complex
  states: {}
- name: cyclic_prefixer
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Add the standard 16-sample cyclic prefix.
    cp_len: '16'
    input_size: '64'
    tagname: '""'
  states: {}
- name: fading
  id: channels_selective_fading_model
  parameters:
    K: '8.0'
    LOS: 'True'
    N: '8'
    comment: Seeded time-varying multipath channel shared by truth and observations.
    delays: (0.0,3.0,8.0)
    fDTs: 40.0/20e6
    mags: (1.0,0.35,0.2)
    ntaps: '16'
    seed: seed+50
  states: {}
- name: fft_first
  id: fft_vxx
  parameters:
    comment: Recover the first shifted frequency-domain L-LTF.
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_second
  id: fft_vxx
  parameters:
    comment: Recover the second shifted frequency-domain L-LTF.
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_truth
  id: fft_vxx
  parameters:
    comment: Recover the noise-free channel-labeled L-LTF.
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: first_sink
  id: blocks_vector_sink_x
  parameters:
    comment: First noisy observation vectors.
    reserve_items: samples
    type: complex
    vlen: '64'
  states: {}
- name: ltf_source
  id: blocks_vector_source_x
  parameters:
    comment: Emit one shifted frequency-domain L-LTF vector per example.
    repeat: 'False'
    type: complex
    vector: list(long_symbol)*samples
    vlen: '64'
  states: {}
- name: noise_first
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    comment: First independently seeded complex Gaussian observation noise.
    noise_type: analog.GR_GAUSSIAN
    seed: seed+101
    type: complex
  states: {}
- name: noise_second
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    comment: Second independently seeded complex Gaussian observation noise.
    noise_type: analog.GR_GAUSSIAN
    seed: seed+202
    type: complex
  states: {}
- name: remove_cp_first
  id: blocks_keep_m_in_n
  parameters:
    comment: Remove the cyclic prefix from the first observation.
    m: '64'
    n: '80'
    offset: '16'
    type: complex
  states: {}
- name: remove_cp_second
  id: blocks_keep_m_in_n
  parameters:
    comment: Remove the cyclic prefix from the second observation.
    m: '64'
    n: '80'
    offset: '16'
    type: complex
  states: {}
- name: remove_cp_truth
  id: blocks_keep_m_in_n
  parameters:
    comment: Preserve the same faded waveform without observation noise.
    m: '64'
    n: '80'
    offset: '16'
    type: complex
  states: {}
- name: save_dataset
  id: snippet
  parameters:
    code: |-
      from pathlib import Path
      import numpy as np

      def vectors(sink):
          values = np.asarray(sink.data(), dtype=np.complex64).reshape(-1, 64)
          if values.shape != (self.samples, 64):
              raise RuntimeError(f'flowgraph produced {values.shape[0]} vectors; expected {self.samples}')
          return values

      output = Path(self.output_file)
      output.parent.mkdir(parents=True, exist_ok=True)
      np.savez(output, first=vectors(self.first_sink), second=vectors(self.second_sink),
               truth=vectors(self.truth_sink))
    comment: Serialize only the three visible vector-sink outputs.
    section: main_after_stop
  states: {}
- name: scale_first
  id: blocks_multiply_const_xx
  parameters:
    comment: Complete the symmetric 1/8 transmitter and receiver scaling.
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: scale_second
  id: blocks_multiply_const_xx
  parameters:
    comment: Complete the symmetric 1/8 transmitter and receiver scaling.
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: scale_truth
  id: blocks_multiply_const_xx
  parameters:
    comment: Complete the symmetric 1/8 transmitter and receiver scaling.
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: second_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Second noisy observation vectors.
    reserve_items: samples
    type: complex
    vlen: '64'
  states: {}
- name: truth_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Noise-free vectors from the identical fading realization.
    reserve_items: samples
    type: complex
    vlen: '64'
  states: {}
- name: tx_ifft
  id: fft_vxx
  parameters:
    comment: Convert each shifted L-LTF into its 64 time-domain samples.
    fft_size: '64'
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: tx_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: Pair with the receiver 1/8 scale for amplitude gain overall.
    const: amplitude/8.0
    type: complex
    vlen: '64'
  states: {}
- name: vectorize_first
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: vectorize_second
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: vectorize_truth
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}

connections:
- [add_first_noise, '0', remove_cp_first, '0']
- [add_second_noise, '0', remove_cp_second, '0']
- [cyclic_prefixer, '0', fading, '0']
- [fading, '0', add_first_noise, '0']
- [fading, '0', add_second_noise, '0']
- [fading, '0', remove_cp_truth, '0']
- [fft_first, '0', scale_first, '0']
- [fft_second, '0', scale_second, '0']
- [fft_truth, '0', scale_truth, '0']
- [ltf_source, '0', tx_ifft, '0']
- [noise_first, '0', add_first_noise, '1']
- [noise_second, '0', add_second_noise, '1']
- [remove_cp_first, '0', vectorize_first, '0']
- [remove_cp_second, '0', vectorize_second, '0']
- [remove_cp_truth, '0', vectorize_truth, '0']
- [scale_first, '0', first_sink, '0']
- [scale_second, '0', second_sink, '0']
- [scale_truth, '0', truth_sink, '0']
- [tx_ifft, '0', tx_scale, '0']
- [tx_scale, '0', cyclic_prefixer, '0']
- [vectorize_first, '0', fft_first, '0']
- [vectorize_second, '0', fft_second, '0']
- [vectorize_truth, '0', fft_truth, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
