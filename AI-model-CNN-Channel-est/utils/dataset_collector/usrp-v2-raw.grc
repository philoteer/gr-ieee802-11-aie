options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx_usrp
    output_language: python
    run_options: run
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.412e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: initial_gains[0]
  states: {}
- name: gain_noise_std_db
  id: variable
  parameters:
    value: '2'
  states: {}
- name: gain_settle_s
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: initial_gains
  id: variable
  parameters:
    value: '[56, 56, 50, 44, 38, 38, 38, 44, 50, 56, 56, 56, 56]'
  states: {}
- name: other_dwell_s
  id: variable
  parameters:
    value: '60'
  states: {}
- name: popular_dwell_s
  id: variable
  parameters:
    value: '180'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '32768'
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.sigmf-data
    type: short
  states: {}
- name: blocks_integrate_clip
  id: blocks_integrate_xx
  parameters:
    decim: '2048'
    type: float
  states: {}
- name: blocks_integrate_power
  id: blocks_integrate_xx
  parameters:
    decim: '2048'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '4'
    type: complex
  states: {}
- name: blocks_probe_clip
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_probe_power
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_threshold_clip
  id: blocks_threshold_ff
  parameters:
    high: 0.95 * 0.95
    init: '0'
    low: 0.95 * 0.95
  states: {}
- name: epy_raw_metadata
  id: epy_block
  parameters:
    _source_code: |
      import json
      import math
      import os
      from pathlib import Path
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      class raw_metadata(gr.sync_block):
          def __init__(self, output_path='out.sigmf-meta', sample_rate=20e6,
                       frequency=2.412e9, gain=44):
              gr.sync_block.__init__(self, name='raw_metadata',
                                     in_sig=[np.complex64], out_sig=[])
              self.path = Path(output_path)
              self.lock = threading.Lock()
              self.pending = []
              self.started = False
              self._recorded_frequency = float(frequency)
              self._recorded_gain = float(gain)
              self.metadata = {
                  'global': {
                      'core:datatype': 'ci16_le',
                      'core:sample_rate': float(sample_rate),
                      'core:version': '1.2.6',
                      'core:dataset': 'out.sigmf-data',
                      'core:hw': 'USRP B210 (UHD), TX/RX',
                      'core:recorder': 'wifi_rx_usrp raw_metadata',
                      'core:description': 'RX antenna TX/RX; complex float quantized to int16 with scale 32768',
                  },
                  'captures': [{'core:sample_start': 0,
                                'core:frequency': self._recorded_frequency}],
                  'annotations': [{'core:sample_start': 0, 'core:label': 'rx-gain',
                                   'core:comment': 'rx_gain_db={:g}'.format(self._recorded_gain)}],
              }
          def _save(self):
              self.path.parent.mkdir(parents=True, exist_ok=True)
              temporary = self.path.with_name(self.path.name + '.tmp')
              with temporary.open('w', encoding='utf-8') as output:
                  json.dump(self.metadata, output, indent=2)
                  output.write('\n')
              os.replace(temporary, self.path)

          def record_change(self, offset, frequency=None, gain=None):
              with self.lock:
                  self.pending.append((int(offset), frequency, gain))

          def work(self, input_items, output_items):
              count = len(input_items[0])
              if not self.started:
                  self.started = True
                  self._save()
              start = self.nitems_read(0)
              stop = start + count
              with self.lock:
                  ready = [event for event in self.pending if event[0] < stop]
                  self.pending = [event for event in self.pending if event[0] >= stop]
              events = {}
              for offset, frequency, gain in ready:
                  event = events.setdefault(max(start, offset), {})
                  if frequency is not None:
                      event['frequency'] = float(frequency)
                  if gain is not None:
                      event['gain'] = float(gain)
              for tag in self.get_tags_in_window(0, 0, count):
                  key = pmt.symbol_to_string(tag.key)
                  offset = int(tag.offset)
                  event = events.setdefault(offset, {})
                  if key == 'rx_freq' and pmt.is_real(tag.value):
                      event['frequency'] = float(pmt.to_double(tag.value))
                  elif key == 'rx_gain' and pmt.is_real(tag.value):
                      event['gain'] = float(pmt.to_double(tag.value))
                  elif key == 'rx_time' and pmt.is_tuple(tag.value):
                      seconds = pmt.tuple_ref(tag.value, 0)
                      fraction = pmt.tuple_ref(tag.value, 1)
                      if pmt.is_uint64(seconds) and pmt.is_real(fraction):
                          event['time'] = (pmt.to_uint64(seconds) +
                                           pmt.to_double(fraction))
              changed = False
              for offset, event in sorted(events.items()):
                  frequency = event.get('frequency')
                  if frequency is not None and math.isfinite(frequency) and frequency != self._recorded_frequency:
                      self._recorded_frequency = frequency
                      if offset == self.metadata['captures'][-1]['core:sample_start']:
                          self.metadata['captures'][-1]['core:frequency'] = frequency
                      else:
                          self.metadata['captures'].append({
                              'core:sample_start': offset, 'core:frequency': frequency})
                      changed = True
                  gain = event.get('gain')
                  if gain is not None and math.isfinite(gain) and gain != self._recorded_gain:
                      self._recorded_gain = gain
                      annotation = {'core:sample_start': offset, 'core:label': 'rx-gain',
                                    'core:comment': 'rx_gain_db={:g}'.format(gain)}
                      if offset == 0:
                          self.metadata['annotations'][0] = annotation
                      else:
                          self.metadata['annotations'].append(annotation)
                      changed = True
                  if 'time' in event:
                      self.metadata['annotations'].append({
                          'core:sample_start': offset, 'core:label': 'rx-time',
                          'core:comment': 'rx_time={:.9f}'.format(event['time'])})
                      changed = True
              if changed:
                  self._save()
              return count

          def stop(self):
              if self.started:
                  self._save()
              return True
    frequency: freq
    gain: gain
    output_path: '"out.sigmf-meta"'
    sample_rate: samp_rate
  states: {}
- name: start_channel_sweep
  id: snippet
  parameters:
    code: |
      import math
      import random
      import threading
      import time

      self.channel_sweep_stop = threading.Event()
      if len(self.initial_gains) != 13:
          raise ValueError('initial_gains must contain 13 channel values')
      self.channel_gain_lut = {channel: self.initial_gains[channel - 1]
                               for channel in range(1, 14)}
      gain_range = self.uhd_usrp_source_0.get_gain_range(0)

      def observe(duration):
          warmup = min(max(0.0, float(self.gain_settle_s)), duration / 3)
          if self.channel_sweep_stop.wait(warmup):
              return None
          deadline = time.monotonic() + duration - warmup
          power_sum = 0.0
          near_full_sum = 0.0
          count = 0
          while not self.channel_sweep_stop.is_set():
              remaining = deadline - time.monotonic()
              if remaining <= 0:
                  break
              if self.channel_sweep_stop.wait(min(0.1, remaining)):
                  return None
              power = self.blocks_probe_power.level() / 2048
              near_full = self.blocks_probe_clip.level() / 2048
              if math.isfinite(power) and power > 0 and 0 <= near_full <= 1:
                  power_sum += power
                  near_full_sum += near_full
                  count += 1
          if count == 0:
              return None
          return math.sqrt(power_sum / count), near_full_sum / count, count

      def record_settings():
          self.epy_raw_metadata.record_change(
              self.uhd_usrp_source_0.nitems_written(0),
              self.uhd_usrp_source_0.get_center_freq(0),
              self.uhd_usrp_source_0.get_gain(0))

      def sweep():
          while not self.channel_sweep_stop.is_set():
              for channel in range(1, 14):
                  if self.channel_sweep_stop.is_set():
                      return
                  frequency = 2.412e9 + (channel - 1) * 5e6
                  dwell = max(0.02, float(self.popular_dwell_s if channel in (1, 5, 9, 13)
                                          else self.other_dwell_s))
                  if self.get_freq() != frequency:
                      self.set_freq(frequency)
                      record_settings()
                  self.set_gain(self.channel_gain_lut[channel])
                  record_settings()
                  print('Wi-Fi channel {}: {:.0f} MHz, gain {:.1f} dB, dwell {} s'.format(
                      channel, frequency / 1e6, self.uhd_usrp_source_0.get_gain(0), dwell),
                      flush=True)
                  level = observe(dwell / 2)
                  if level is not None:
                      rms, near_full, count = level
                      if rms > 0 and math.isfinite(rms):
                          delta = 6.0 if rms < 0.14 else (-6.0 if rms > 0.28 else 0.0)
                          if near_full > 1e-4:
                              delta = min(delta, -6.0)
                          noise = random.gauss(0, max(0.0, float(self.gain_noise_std_db)))
                          candidate = max(gain_range.start(), min(gain_range.stop(),
                              self.channel_gain_lut[channel] + delta + noise))
                          self.set_gain(candidate)
                          record_settings()
                          self.channel_gain_lut[channel] = self.uhd_usrp_source_0.get_gain(0)
                          print('Wi-Fi channel {}: rms {:.3f}, near full scale {:.4%} of {} polls, gain {:.1f} dB'.format(
                              channel, rms, near_full, count, self.channel_gain_lut[channel]),
                              flush=True)
                  if self.channel_sweep_stop.wait(dwell / 2):
                      return

      self.channel_sweep_thread = threading.Thread(target=sweep, daemon=True)
      self.channel_sweep_thread.start()
    section: main_after_start
  states: {}
- name: stop_channel_sweep
  id: snippet
  parameters:
    code: |-
      self.channel_sweep_stop.set()
      self.channel_sweep_thread.join(timeout=1)
    section: main_after_stop
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    dev_addr: '"type=b200"'
    gain0: gain
    minoutbuf: '1048576'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_power, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_clip, '0']
- [blocks_integrate_clip, '0', blocks_probe_clip, '0']
- [blocks_integrate_power, '0', blocks_probe_power, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_threshold_clip, '0', blocks_integrate_clip, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_interleaved_short_0, '0']
- [uhd_usrp_source_0, '0', blocks_keep_one_in_n_0, '0']
- [uhd_usrp_source_0, '0', epy_raw_metadata, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
