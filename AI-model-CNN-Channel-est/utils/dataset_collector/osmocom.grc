options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: gain_BB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gain_IF
  id: variable
  parameters:
    value: '32'
  states: {}
- name: gain_RF
  id: variable
  parameters:
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: attach_collector_radio
  id: snippet
  parameters:
    code: self.epy_xy_collector.radio = self.osmosdr_source_0
    section: main_after_init
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_xy_collector
  id: epy_block
  parameters:
    _source_code: |-
      import json
      import math
      import os
      from datetime import datetime, timezone
      from pathlib import Path
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      PILOT_POLARITY = (
          1, 1, 1, 1, -1, -1, -1, 1, -1, -1, -1, -1, 1, 1, -1, 1,
          -1, -1, 1, 1, -1, 1, 1, -1, 1, 1, 1, 1, 1, 1, -1, 1,
          1, 1, -1, 1, 1, -1, -1, 1, 1, 1, -1, 1, -1, -1, -1, 1,
          -1, 1, -1, -1, 1, -1, -1, 1, 1, 1, 1, 1, -1, -1, 1, 1,
          -1, -1, 1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, -1, -1,
          -1, 1, -1, -1, 1, -1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1,
          -1, -1, -1, -1, -1, 1, -1, 1, 1, -1, 1, -1, 1, 1, 1, -1,
          -1, 1, -1, -1, -1, 1, 1, 1, -1, -1, -1, -1, -1, -1, -1,
      )


      class xy_collector(gr.basic_block):
          def __init__(self, output_path='data/xy_samples', report_interval=25,
                       center_frequency=2.417e9, sample_rate=20e6,
                       rf_gain=14, if_gain=32, bb_gain=0):
              gr.basic_block.__init__(self, name='xy_collector', in_sig=[], out_sig=[])
              self.output_base = Path(output_path)
              self.data_path = None
              self.meta_path = None
              self.data_file = None
              self.report_interval = max(1, int(report_interval))
              self.frames = 0
              self.sample_count = 0
              self.metadata = {
                  'global': {
                      'core:datatype': 'cf32_le',
                      'core:num_channels': 2,
                      'core:version': '1.2.6',
                      'core:recorder': 'wifi_rx xy_collector',
                      'core:hw': 'osmosdr receiver',
                      'core:description': (
                          'CRC-valid Wi-Fi payload symbols; channel 0 unequalized received, '
                          'channel 1 transmitted ground truth; 52 occupied subcarriers per OFDM symbol.\n'
                          'RF center frequency: {} Hz\nADC sample rate: {} samples/s\n'
                          'Requested RF gain: {} dB\nRequested IF gain: {} dB\nRequested BB gain: {} dB'.format(
                              center_frequency, sample_rate, rf_gain, if_gain, bb_gain)),
                  },
                  'captures': [],
                  'annotations': [],
              }
              self.center_frequency = float(center_frequency)
              self.rf_gain = float(rf_gain)
              self.if_gain = float(if_gain)
              self.bb_gain = float(bb_gain)
              self.radio = None
              self.lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._collect)

          def _open_recording(self):
              self.output_base.parent.mkdir(parents=True, exist_ok=True)
              stamp = datetime.now(timezone.utc).strftime('%Y%m%dT%H%M%S%fZ')
              base = self.output_base.with_name(self.output_base.name + '-' + stamp)
              self.data_path = base.with_suffix('.sigmf-data')
              self.meta_path = base.with_suffix('.sigmf-meta')
              self.data_file = self.data_path.open('xb')

          def _save_metadata(self):
              temporary = self.meta_path.with_name(self.meta_path.name + '.tmp')
              with temporary.open('w', encoding='utf-8') as output:
                  json.dump(self.metadata, output, indent=2)
                  output.write('\n')
              os.replace(temporary, self.meta_path)

          @staticmethod
          def _field(metadata, name):
              value = pmt.dict_ref(metadata, pmt.intern(name), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          @staticmethod
          def _real_field(metadata, name):
              value = pmt.dict_ref(metadata, pmt.intern(name), pmt.PMT_NIL)
              if pmt.is_real(value):
                  number = float(pmt.to_double(value))
                  return number if math.isfinite(number) else None
              return None

          def _collect(self, message):
              if not pmt.is_pair(message):
                  return
              metadata, iq = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(metadata) or not pmt.is_dict(iq):
                  return
              vectors = []
              for name in ('transmitted_iq', 'equalized_iq', 'received_iq'):
                  value = pmt.dict_ref(iq, pmt.intern(name), pmt.PMT_NIL)
                  if not pmt.is_c32vector(value):
                      return
                  vectors.append(np.asarray(pmt.c32vector_elements(value), dtype=np.complex64))
              x, y, unequalized = vectors
              frame_bytes = self._field(metadata, 'frame bytes')
              encoding = self._field(metadata, 'encoding')
              if (frame_bytes is None or encoding is None or x.size == 0 or
                      x.size % 48 or x.size != y.size or unequalized.size != x.size // 48 * 52 or
                      not np.all(np.isfinite(x)) or not np.all(np.isfinite(y)) or not np.all(np.isfinite(unequalized))):
                  return
              expected = np.empty((x.size // 48, 52), dtype=np.complex64)
              expected[:, [i for i in range(52) if i not in (5, 19, 32, 46)]] = x.reshape(-1, 48)
              polarity = np.asarray([PILOT_POLARITY[(n - 2) % 127] for n in range(3, 3 + expected.shape[0])], dtype=np.float32)
              expected[:, (5, 19, 32, 46)] = polarity[:, None] * np.array([1, 1, 1, -1], dtype=np.float32)
              samples = np.empty((unequalized.size, 2), dtype='<c8')
              samples[:, 0] = unequalized
              samples[:, 1] = expected.ravel()
              frequency = self._real_field(metadata, 'nominal frequency')
              if frequency is None or frequency <= 0:
                  frequency = self.center_frequency
              diagnostics = ['frame_bytes={}', 'encoding={}']
              values = [frame_bytes, encoding]
              for name, label in (('snr', 'snr_db'),
                                  ('frequency offset', 'frequency_offset_hz'),
                                  ('beta', 'pilot_phase_rad')):
                  value = self._real_field(metadata, name)
                  if value is not None:
                      diagnostics.append(label + '={}')
                      values.append(value)
              error = y.astype(np.complex128) - x
              error_power = float(np.vdot(error, error).real)
              reference_power = float(np.vdot(x.astype(np.complex128), x).real)
              if reference_power > 0:
                  diagnostics.append('evm_rms_percent={}')
                  values.append(100.0 * math.sqrt(error_power / reference_power))
              received_bits = pmt.dict_ref(iq, pmt.intern('pre_viterbi'), pmt.PMT_NIL)
              corrected_bits = pmt.dict_ref(iq, pmt.intern('corrected_coded'), pmt.PMT_NIL)
              if pmt.is_u8vector(received_bits) and pmt.is_u8vector(corrected_bits):
                  received = np.asarray(pmt.u8vector_elements(received_bits), dtype=np.uint8)
                  corrected = np.asarray(pmt.u8vector_elements(corrected_bits), dtype=np.uint8)
                  if (received.size and received.size == corrected.size and
                          np.all(received <= 1) and np.all(corrected <= 1)):
                      diagnostics.append('pre_fec_ber={}')
                      values.append(float(np.count_nonzero(received != corrected) / received.size))
              with self.lock:
                  gains = (self.rf_gain, self.if_gain, self.bb_gain)
                  if self.radio is not None and all(name in self.radio.get_gain_names(0) for name in ('RF', 'IF', 'BB')):
                      gains = tuple(self.radio.get_gain(name, 0) for name in ('RF', 'IF', 'BB'))
                  if self.data_file is None:
                      self._open_recording()
                  self.data_file.write(samples.tobytes())
                  self.data_file.flush()
                  self.metadata['captures'].append({
                      'core:sample_start': self.sample_count,
                      'core:frequency': frequency,
                  })
                  self.metadata['annotations'].append({
                      'core:sample_start': self.sample_count,
                      'core:sample_count': int(samples.shape[0]),
                      'core:label': 'wifi-frame',
                      'core:comment': '; '.join(diagnostics + ['rf_gain_db={}', 'if_gain_db={}', 'bb_gain_db={}']).format(*(values + list(gains))),
                  })
                  self.sample_count += samples.shape[0]
                  self._save_metadata()
                  self.frames += 1
                  if self.frames == 1 or self.frames % self.report_interval == 0:
                      print('Collected {} CRC-valid Wi-Fi frames ({} symbols): {}'.format(
                          self.frames, samples.shape[0], self.data_path), flush=True)

          def stop(self):
              with self.lock:
                  if self.data_file is not None:
                      self.data_file.close()
                      self.data_file = None
              return True
    bb_gain: gain_BB
    center_frequency: freq
    if_gain: gain_IF
    output_path: '"data/xy_samples"'
    report_interval: '25'
    rf_gain: gain_RF
    sample_rate: samp_rate
  states: {}
- name: evm_build_mode_check
  id: snippet
  parameters:
    code: |-
      from pathlib import Path

      build = Path('../../kernel/build')
      marker = build / 'frame_equalizer_build_mode.txt'
      artifacts = [build / 'final.xclbin', build / 'insts.bin']
      missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
      if missing: raise RuntimeError('EVM diagnostics require kernel build output(s): ' + ', '.join(missing) + '; run `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile` from stage42/')
      mode = dict((parts[0].strip(), parts[1].strip()) for parts in (line.split('=', 1) for line in marker.read_text(encoding='ascii').splitlines()) if len(parts) == 2)
      if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '1': raise RuntimeError('EVM diagnostics require DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1; rebuild with `make -C kernel DFRAME_EQUALIZER_OUTPUT_SYMBOLS=1 compile`')
      if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts): raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild the kernel')
    section: init_before_blocks
  states: {}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_evm_0_0
  id: mlir_aie_mlir_aie_80211_phy_evm
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"../../kernel/build/insts.bin"'
    path_xclbin: '"../../kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: gain_BB
    bw0: samp_rate
    freq0: freq
    gain0: gain_RF
    gain_mode0: 'False'
    if_gain0: gain_IF
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, epy_xy_collector, diag]
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_evm_0_0, '0']
- [mlir_aie_mlir_aie_80211_phy_evm_0_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
