options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "Linear Comb", "STA"]'
    num_opts: '0'
    options: '[0, 1, 2, 3]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: diagnostic_estimator
  id: variable
  parameters:
    comment: Label the selected GNU Radio channel estimator in diagnostic records.
    value: '[''LS'', ''LMS'', ''COMB'', ''STA''][chan_est]'
  states: {}
- name: diagnostic_evm_output
  id: variable
  parameters:
    comment: Bounded equalized-payload EVM export.
    value: '"data/tmp_out/channel_estimator_evm.jsonl"'
  states: {}
- name: diagnostic_max_records
  id: variable
  parameters:
    comment: Maximum number of frame and CRC event records written to JSONL.
    value: '10000'
  states: {}
- name: diagnostic_output
  id: variable
  parameters:
    comment: Bounded channel-estimator diagnostic export.
    value: '"data/tmp_out/channel_estimator_diagnostic.jsonl"'
  states: {}
- name: freq
  id: variable_qtgui_chooser
  parameters:
    labels: '[''  1 | 2412.0 | 11g'', ''  2 | 2417.0 | 11g'', ''  3 | 2422.0 | 11g'', ''  4 | 2427.0 | 11g'', ''  5 | 2432.0 | 11g'', ''  6 | 2437.0 | 11g'', ''  7 | 2442.0 | 11g'', ''  8 | 2447.0 | 11g'', ''  9 | 2452.0 | 11g'', '' 10 | 2457.0 | 11g'', '' 11 | 2462.0 | 11g'', '' 12 | 2467.0 | 11g'', '' 13 | 2472.0 | 11g'', '' 14 | 2484.0 | 11g'', '' 34 | 5170.0 | 11a'', '' 36 | 5180.0 | 11a'', '' 38 | 5190.0 | 11a'', '' 40 | 5200.0 | 11a'', '' 42 | 5210.0 | 11a'', '' 44 | 5220.0 | 11a'', '' 46 | 5230.0 | 11a'', '' 48 | 5240.0 | 11a'', '' 50 | 5250.0 | 11a'', '' 52 | 5260.0 | 11a'', '' 54 | 5270.0 | 11a'', '' 56 | 5280.0 | 11a'', '' 58 | 5290.0 | 11a'', '' 60 | 5300.0 | 11a'', '' 62 | 5310.0 | 11a'', '' 64 | 5320.0 | 11a'', ''100 | 5500.0 | 11a'', ''102 | 5510.0 | 11a'', ''104 | 5520.0 | 11a'', ''106 | 5530.0 | 11a'', ''108 | 5540.0 | 11a'', ''110 | 5550.0 | 11a'', ''112 | 5560.0 | 11a'', ''114 | 5570.0 | 11a'', ''116 | 5580.0 | 11a'', ''118 | 5590.0 | 11a'', ''120 | 5600.0 | 11a'', ''122 | 5610.0 | 11a'', ''124 | 5620.0 | 11a'', ''126 | 5630.0 | 11a'', ''128 | 5640.0 | 11a'', ''132 | 5660.0 | 11a'', ''134 | 5670.0 | 11a'', ''136 | 5680.0 | 11a'', ''138 | 5690.0 | 11a'', ''140 | 5700.0 | 11a'', ''142 | 5710.0 | 11a'', ''144 | 5720.0 | 11a'', ''149 | 5745.0 | 11a (SRD)'', ''151 | 5755.0 | 11a (SRD)'', ''153 | 5765.0 | 11a (SRD)'', ''155 | 5775.0 | 11a (SRD)'', ''157 | 5785.0 | 11a (SRD)'', ''159 | 5795.0 | 11a (SRD)'', ''161 | 5805.0 | 11a (SRD)'', ''165 | 5825.0 | 11a (SRD)'', ''172 | 5860.0 | 11p'', ''174 | 5870.0 | 11p'', ''176 | 5880.0 | 11p'', ''178 | 5890.0 | 11p'', ''180 | 5900.0 | 11p'', ''182 | 5910.0 | 11p'', ''184 | 5920.0 | 11p'']'
    num_opts: '0'
    options: '[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5250000000.0, 5260000000.0, 5270000000.0, 5280000000.0, 5290000000.0, 5300000000.0, 5310000000.0, 5320000000.0, 5500000000.0, 5510000000.0, 5520000000.0, 5530000000.0, 5540000000.0, 5550000000.0, 5560000000.0, 5570000000.0, 5580000000.0, 5590000000.0, 5600000000.0, 5610000000.0, 5620000000.0, 5630000000.0, 5640000000.0, 5660000000.0, 5670000000.0, 5680000000.0, 5690000000.0, 5700000000.0, 5710000000.0, 5720000000.0, 5745000000.0, 5755000000.0, 5765000000.0, 5775000000.0, 5785000000.0, 5795000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]'
    type: real
    value: '2417000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/tmp_out/orig.pcap
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: data/raw_capture/stress_test.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_channel_estimator_diagnostic
  id: epy_block
  parameters:
    _source_code: |
      # This block observes frame tags from the AIE receiver and produces
      # bounded diagnostic records and display vectors without altering decoded bytes.
      #
      # Input stream:
      #   The AIE hard-decision byte stream, used only to locate absolute tag offsets.
      #
      # Message input:
      #   The MAC decoder emits one message after a CRC-valid packet. Its diag port sends one metadata
      #   dictionary containing coded-bit vectors and optional IQ vectors for BER/EVM.
      #
      # Stream outputs:
      #   CSI magnitude, CSI phase residual, delay profile, and eight scalar metrics.
      #
      # The analyzer deliberately does not forward its input. A separate branch keeps
      # the production byte stream connected directly to the MAC decoder.
      #
      # JSONL events:
      #   frame       One valid CSI tag with raw CSI and derived metrics.
      #   crc_ok      One payload passed the MAC decoder CRC check.
      #   invalid_csi A tag was malformed or contained no usable channel power.
      #   pre_fec_coded_ber Counts mismatches between received coded bits and the
      #                     decoder-corrected re-encoded bits on CRC-valid frames.
      #
      # Coded BER uses the bit region published by decode_mac_BER, which omits the
      # final OFDM symbol; failed-CRC frames do not provide a comparison reference.
      #
      # Metric meanings:
      #   Flatness and deepest fade describe frequency selectivity.
      #   Noise enhancement estimates sensitivity of a reciprocal equalizer.
      #   Phase residual removes linear timing slope and exposes ripple.
      #   Delay spread is an approximate 64-point impulse-response measurement.

      import json
      import os
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class channel_estimator_diagnostic(gr.basic_block):
          """Analyze frame-level CSI tags and generate quality metrics.

              Args:
                  output_path: JSONL destination. An empty string disables file output.
                  max_records: Maximum number of JSONL records retained.
                  report_interval: Number of frames between console summaries.
                  headless_idle_seconds: Inactivity timeout for unattended finite-file runs.
                  estimator_label: Human-readable label identifying the XCLBIN estimator.
                  sample_rate: Input sample rate in samples per second.

              The input is intentionally not forwarded. The production receiver branch
              remains connected directly to the MAC decoder.
              """

          def __init__(self, output_path="data/tmp_out/channel_estimator_diagnostic.jsonl",
                       max_records=10000, report_interval=25,
                       headless_idle_seconds=10.0, estimator_label="CNN", sample_rate=20e6):
              # The first three outputs are vectors; the remaining eight outputs are
              # scalar metrics repeated once per analyzed frame for the GUI sinks.
              gr.basic_block.__init__(
                  self,
                  name="channel_estimator_diagnostic",
                  in_sig=[np.int8],
                  out_sig=[
                      (np.float32, 53), (np.float32, 53), (np.float32, 64),
                      np.float32, np.float32, np.float32, np.float32,
                      np.float32, np.float32, np.float32, np.float32,
                  ],
              )
              # Queue completed frame analyses until all output ports can accept one item.
              self.output_path = output_path
              self.sample_rate = float(sample_rate)
              if self.sample_rate <= 0.0:
                  raise ValueError("sample_rate must be positive")
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.pending = []
              self.previous_csi = None
              self.frame_count = 0
              self.crc_valid_count = 0
              self.record_count = 0
              self.pre_fec_bit_errors = 0
              self.pre_fec_bits_compared = 0
              self.pre_fec_ber_samples = 0
              self.evm_samples = 0
              self.evm_error_power = 0.0
              self.evm_reference_power = 0.0
              self.evm_aligned_percent_sum = 0.0
              self.evm_lock = threading.Lock()
              self.lock = threading.Lock()
              self.last_work = time.monotonic()
              self.seen_input = False
              self.stopping = False
              self.message_port_register_in(pmt.intern("crc_ok"))
              self.set_msg_handler(pmt.intern("crc_ok"), self._handle_crc_ok)
              self.message_port_register_in(pmt.intern("diag"))
              self.set_msg_handler(pmt.intern("diag"), self._handle_diag)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              self.output_file = open(output_path, "w", encoding="ascii") if output_path else None

              # In unattended runs the watchdog quits Qt after finite input stops.
              if os.environ.get("WIFI_DIAGNOSTIC_HEADLESS") == "1":
                  self.headless_thread = threading.Thread(
                      target=self._headless_watchdog,
                      args=(max(1.0, float(headless_idle_seconds)),),
                      daemon=True,
                  )
                  self.headless_thread.start()

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          @staticmethod
          def _finite(value):
              return float(value) if np.isfinite(value) else None

          def _write_record(self, record):
              with self.lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(json.dumps(record, separators=(",", ":"), allow_nan=False) + "\n")
                  self.output_file.flush()
                  self.record_count += 1

          def _handle_crc_ok(self, _message):
              with self.lock:
                  self.crc_valid_count += 1
                  crc_valid_count = self.crc_valid_count
              self._write_record({
                  "event": "crc_ok",
                  "crc_valid_count": crc_valid_count,
                  "estimator": self.estimator_label,
              })

          def _headless_watchdog(self, idle_seconds):
              while not self.stopping:
                  time.sleep(0.25)
                  if self.seen_input and time.monotonic() - self.last_work >= idle_seconds:
                      try:
                          from PyQt5 import QtWidgets
                          app = QtWidgets.QApplication.instance()
                          if app is not None:
                              app.quit()
                      except ImportError:
                          pass
                      return

          def _decode_tags(self, tags):
              grouped = {}
              for tag in tags:
                  key = pmt.symbol_to_string(tag.key)
                  grouped.setdefault(int(tag.offset), {})[key] = tag.value
              return grouped

          def _analyze(self, offset, values):
              # The AIE adapter publishes CSI as 52 occupied carriers: -26..-1 and
              # +1..+26. A missing CSI tag means this offset is not a frame record.
              if "csi" not in values:
                  return
              csi = np.asarray(pmt.c32vector_elements(values["csi"]), dtype=np.complex64)
              if csi.size != 52 or not np.all(np.isfinite(csi)):
                  self._write_record({
                      "event": "invalid_csi",
                      "offset": offset,
                      "size": int(csi.size),
                      "estimator": self.estimator_label,
                  })
                  return

              power = np.abs(csi).astype(np.float64) ** 2
              mean_power = float(np.mean(power))
              if mean_power <= np.finfo(np.float64).tiny:
                  self._write_record({
                      "event": "invalid_csi",
                      "offset": offset,
                      "reason": "zero_power",
                      "estimator": self.estimator_label,
                  })
                  return

              floor = max(mean_power * 1e-12, np.finfo(np.float64).tiny)
              # Use a relative floor so logarithms remain finite for deep fades.
              median_power = max(float(np.median(power)), floor)
              magnitude_db = 10.0 * np.log10(np.maximum(power, floor) / median_power)
              subcarriers = np.concatenate((np.arange(-26, 0), np.arange(1, 27)))
              # Remove the best-fit linear phase slope before displaying phase ripple.
              unwrapped_phase = np.unwrap(np.angle(csi).astype(np.float64))
              phase_fit = np.polyfit(subcarriers, unwrapped_phase, 1)
              phase_residual = unwrapped_phase - np.polyval(phase_fit, subcarriers)

              shifted_channel = np.zeros(64, dtype=np.complex128)
              # Reinsert the occupied carriers into shifted 64-point FFT-bin order.
              # DC and guard bins remain zero because they are not channel estimates.
              shifted_channel[6:32] = csi[:26]
              shifted_channel[33:59] = csi[26:]
              impulse = np.fft.ifft(np.fft.ifftshift(shifted_channel))
              delay_power = np.abs(impulse) ** 2
              # The 20 MHz sample period is derived from the configured sample rate; report RMS delay in nanoseconds.
              delay_power /= max(float(np.max(delay_power)), floor)
              delay_profile_db = 10.0 * np.log10(np.maximum(delay_power, 1e-8))
              peak = int(np.argmax(delay_power))
              distances = (np.arange(64) - peak + 32) % 64 - 32
              delay_weight = delay_power / np.sum(delay_power)
              mean_delay = float(np.sum(distances * delay_weight))
              rms_delay_ns = (1e9 / self.sample_rate) * np.sqrt(
                  np.sum(((distances - mean_delay) ** 2) * delay_weight)
              )

              spectral_flatness_db = 10.0 * np.log10(
                  np.exp(np.mean(np.log(np.maximum(power, floor)))) / mean_power
              )
              noise_enhancement_db = 10.0 * np.log10(
                  mean_power * np.mean(1.0 / np.maximum(power, floor))
              )
              deepest_fade_db = 10.0 * np.log10(max(float(np.min(power)), floor) / median_power)
              if self.previous_csi is None:
                  stability = 0.0
              else:
                  # Correlation is insensitive to overall gain and is useful for spotting
                  # packet-to-packet channel changes or unstable estimates.
                  denominator = np.linalg.norm(self.previous_csi) * np.linalg.norm(csi)
                  stability = float(abs(np.vdot(self.previous_csi, csi)) / denominator) if denominator else 0.0
              self.previous_csi = csi.copy()

              self.frame_count += 1
              snr_db = pmt.to_double(values["snr"]) if "snr" in values else np.nan
              frequency_offset_hz = (
                  pmt.to_double(values["frequency offset"])
                  if "frequency offset" in values else np.nan
              )
              beta_rad = pmt.to_double(values["beta"]) if "beta" in values else np.nan
              frame_bytes = pmt.to_uint64(values["frame bytes"]) if "frame bytes" in values else 0
              encoding = pmt.to_uint64(values["encoding"]) if "encoding" in values else 0
              with self.lock:
                  crc_valid_count = self.crc_valid_count

              metrics = {
                  "snr_db": self._finite(snr_db),
                  "frequency_offset_hz": self._finite(frequency_offset_hz),
                  "beta_rad": self._finite(beta_rad),
                  "deepest_fade_db": self._finite(deepest_fade_db),
                  "spectral_flatness_db": self._finite(spectral_flatness_db),
                  "noise_enhancement_db": self._finite(noise_enhancement_db),
                  "phase_slope_rad_per_subcarrier": self._finite(phase_fit[0]),
                  "phase_residual_rms_rad": self._finite(np.sqrt(np.mean(phase_residual ** 2))),
                  "peak_delay_sample": peak,
                  "rms_delay_spread_ns": self._finite(rms_delay_ns),
                  "previous_csi_correlation": self._finite(stability),
              }
              self._write_record({
                  "event": "frame",
                  "frame_index": self.frame_count,
                  "offset": offset,
                  "estimator": self.estimator_label,
                  "frame_bytes": int(frame_bytes),
                  "encoding": int(encoding),
                  "crc_valid_count": crc_valid_count,
                  "metrics": metrics,
                  "csi_real": csi.real.astype(float).tolist(),
                  "csi_imag": csi.imag.astype(float).tolist(),
              })
              self.pending.append((
                  np.insert(magnitude_db, 26, -50.0).astype(np.float32),
                  np.insert(phase_residual, 26, 0.0).astype(np.float32),
                  delay_profile_db.astype(np.float32),
                  np.asarray((
                      snr_db, frequency_offset_hz, deepest_fade_db,
                      spectral_flatness_db, noise_enhancement_db,
                      rms_delay_ns, stability,
                      crc_valid_count / self.frame_count,
                  ), dtype=np.float32),
              ))

              if self.frame_count % self.report_interval == 0:
                  ratio = crc_valid_count / self.frame_count
                  print(
                      "channel diagnostic: frames={} crc_ok={} ratio={:.3f} "
                      "snr_db={:.2f} fade_db={:.2f} stability={:.4f} delay_ns={:.1f}".format(
                          self.frame_count, crc_valid_count, ratio, snr_db,
                          deepest_fade_db, stability, rms_delay_ns
                      )
                  )

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              if len(in0):
                  self.seen_input = True
                  self.last_work = time.monotonic()
                  start = self.nitems_read(0)
                  tags = self.get_tags_in_range(0, start, start + len(in0))
                  for offset, values in sorted(self._decode_tags(tags).items()):
                      self._analyze(offset, values)
                  self.consume(0, len(in0))

              produced = min(min(map(len, output_items)), len(self.pending))
              for index in range(produced):
                  magnitude_db, phase_residual, delay_profile_db, metrics = self.pending.pop(0)
                  output_items[0][index] = magnitude_db
                  output_items[1][index] = phase_residual
                  output_items[2][index] = delay_profile_db
                  for metric_index in range(8):
                      output_items[3 + metric_index][index] = metrics[metric_index]
              return produced

          def stop(self):
              self.stopping = True
              with self.lock:
                  if self.output_file is not None:
                      self.output_file.close()
                      self.output_file = None
              return True

          def _metadata_uint64(self, metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _record_coded_ber(self, metadata, rx_bits, reference_bits):
              frame_bytes = self._metadata_uint64(metadata, 'frame bytes')
              encoding = self._metadata_uint64(metadata, 'encoding')
              if rx_bits.size == 0 or rx_bits.size != reference_bits.size:
                  self._write_record({
                      'event': 'invalid_coded_ber_pair',
                      'received_bits': int(rx_bits.size),
                      'reference_bits': int(reference_bits.size),
                      'frame_bytes': frame_bytes,
                      'encoding': encoding,
                      'estimator': self.estimator_label,
                  })
                  return
              if np.any(rx_bits > 1) or np.any(reference_bits > 1):
                  self._write_record({
                      'event': 'invalid_coded_ber_pair',
                      'reason': 'values_are_not_bits',
                      'estimator': self.estimator_label,
                  })
                  return

              bit_errors = int(np.count_nonzero(rx_bits != reference_bits))
              bits_compared = int(rx_bits.size)
              sample_ber = bit_errors / bits_compared
              self.pre_fec_ber_samples += 1
              self.pre_fec_bit_errors += bit_errors
              self.pre_fec_bits_compared += bits_compared
              cumulative_ber = self.pre_fec_bit_errors / self.pre_fec_bits_compared
              self._write_record({
                  'event': 'pre_fec_coded_ber',
                  'sample_index': self.pre_fec_ber_samples,
                  'frame_bytes': frame_bytes,
                  'encoding': encoding,
                  'bit_errors': bit_errors,
                  'bits_compared': bits_compared,
                  'ber': sample_ber,
                  'cumulative_bit_errors': self.pre_fec_bit_errors,
                  'cumulative_bits_compared': self.pre_fec_bits_compared,
                  'cumulative_ber': cumulative_ber,
                  'region': 'deinterleaved coded bits, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              print(
                  'pre-FEC coded BER sample {}: {}/{} ({:.6g}); cumulative {:.6g}'.format(
                      self.pre_fec_ber_samples, bit_errors, bits_compared,
                      sample_ber, cumulative_ber
                  )
              )

          def _handle_diag(self, message):
              # The decoder combines coded-bit and IQ diagnostics in one PDU dictionary.
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  self._write_record({
                      'event': 'invalid_coded_ber_message',
                      'estimator': self.estimator_label,
                  })
                  return
              metadata = pmt.car(message)
              diagnostic = pmt.cdr(message)
              received = pmt.dict_ref(diagnostic, pmt.intern('pre_viterbi'), pmt.PMT_NIL)
              corrected = pmt.dict_ref(diagnostic, pmt.intern('corrected_coded'), pmt.PMT_NIL)
              if not pmt.is_u8vector(received) or not pmt.is_u8vector(corrected):
                  self._write_record({
                      'event': 'invalid_coded_ber_message',
                      'reason': 'coded_bit_vectors_missing',
                      'estimator': self.estimator_label,
                  })
                  return
              received = np.asarray(pmt.u8vector_elements(received), dtype=np.uint8)
              corrected = np.asarray(pmt.u8vector_elements(corrected), dtype=np.uint8)
              self._record_coded_ber(metadata, received, corrected)
    estimator_label: diagnostic_estimator
    headless_idle_seconds: '10.0'
    max_records: diagnostic_max_records
    output_path: diagnostic_output
    report_interval: '25'
    sample_rate: samp_rate
  states: {}
- name: epy_evm_diagnostic
  id: epy_block
  parameters:
    _source_code: |-
      import json
      import os
      import threading

      import numpy as np
      import pmt
      from gnuradio import gr


      class evm_diagnostic(gr.basic_block):
          def __init__(self, output_path='data/tmp_out/channel_estimator_evm.jsonl',
                       max_records=10000, report_interval=25, estimator_label='LS'):
              gr.basic_block.__init__(
                  self,
                  name='evm_diagnostic',
                  in_sig=[np.int8],
                  out_sig=[],
              )
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.output_file = None
              self.max_records = max(0, int(max_records))
              self.report_interval = max(1, int(report_interval))
              self.estimator_label = str(estimator_label)
              self.record_count = 0
              self.evm_samples = 0
              self.error_power_sum = 0.0
              self.reference_power_sum = 0.0
              self.aligned_evm_sum = 0.0
              self.output_lock = threading.Lock()
              self.message_port_register_in(pmt.intern('diag'))
              self.set_msg_handler(pmt.intern('diag'), self._handle_iq_data)

              directory = os.path.dirname(output_path)
              if directory:
                  os.makedirs(directory, exist_ok=True)
              if output_path:
                  self.output_file = open(output_path, 'w', encoding='ascii')

          def forecast(self, noutput_items, ninputs):
              return [1] * ninputs

          def general_work(self, input_items, output_items):
              if len(input_items[0]):
                  self.consume(0, len(input_items[0]))
              return 0

          def _write_record(self, record):
              with self.output_lock:
                  if self.output_file is None or self.record_count >= self.max_records:
                      return
                  self.output_file.write(
                      json.dumps(record, separators=(',', ':'), allow_nan=False) + '\n'
                  )
                  self.output_file.flush()
                  self.record_count += 1

          @staticmethod
          def _metadata_uint64(metadata, key):
              if not pmt.is_dict(metadata):
                  return None
              value = pmt.dict_ref(metadata, pmt.intern(key), pmt.PMT_NIL)
              return int(pmt.to_uint64(value)) if pmt.is_uint64(value) else None

          def _handle_iq_data(self, message):
              if not pmt.is_pair(message) or not pmt.is_dict(pmt.cdr(message)):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'expected_metadata_and_iq_dictionary',
                  })
                  return

              metadata = pmt.car(message)
              iq_data = pmt.cdr(message)
              vectors = {}
              for key in ('transmitted_iq', 'received_iq', 'equalized_iq'):
                  value = pmt.dict_ref(iq_data, pmt.intern(key), pmt.PMT_NIL)
                  if not pmt.is_c32vector(value):
                      self._write_record({
                          'event': 'invalid_evm_message',
                          'reason': 'missing_complex_vector',
                          'vector': key,
                      })
                      return
                  vectors[key] = np.asarray(
                      pmt.c32vector_elements(value), dtype=np.complex128
                  )

              transmitted = vectors['transmitted_iq']
              received = vectors['received_iq']
              equalized = vectors['equalized_iq']
              if (transmitted.size == 0 or transmitted.size % 48 != 0 or
                      received.size != transmitted.size or
                      equalized.size != transmitted.size or
                      not np.all(np.isfinite(transmitted)) or
                      not np.all(np.isfinite(received)) or
                      not np.all(np.isfinite(equalized))):
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'invalid_vector_size_or_nonfinite_values',
                      'transmitted_iq_size': int(transmitted.size),
                      'received_iq_size': int(received.size),
                      'equalized_iq_size': int(equalized.size),
                  })
                  return

              reference_power = float(np.vdot(transmitted, transmitted).real)
              if reference_power <= np.finfo(np.float64).tiny:
                  self._write_record({
                      'event': 'invalid_evm_message',
                      'reason': 'zero_reference_power',
                  })
                  return

              error = equalized - transmitted
              error_power = float(np.vdot(error, error).real)
              evm_ratio = float(np.sqrt(error_power / reference_power))
              gain = np.vdot(transmitted, equalized) / reference_power
              aligned_error = equalized / gain - transmitted if abs(gain) else error
              aligned_evm_ratio = float(np.sqrt(
                  np.vdot(aligned_error, aligned_error).real / reference_power
              ))
              evm_percent = 100.0 * evm_ratio
              aligned_evm_percent = 100.0 * aligned_evm_ratio
              evm_db = float(20.0 * np.log10(max(evm_ratio, 1e-15)))
              frame_bytes = self._metadata_uint64(metadata, 'frame bytes')
              encoding = self._metadata_uint64(metadata, 'encoding')

              self.evm_samples += 1
              self.error_power_sum += error_power
              self.reference_power_sum += reference_power
              self.aligned_evm_sum += aligned_evm_percent
              cumulative_evm_percent = float(100.0 * np.sqrt(
                  self.error_power_sum / self.reference_power_sum
              ))
              mean_aligned_evm_percent = self.aligned_evm_sum / self.evm_samples
              self._write_record({
                  'event': 'evm',
                  'sample_index': self.evm_samples,
                  'frame_bytes': frame_bytes,
                  'encoding': encoding,
                  'payload_symbols_compared': int(transmitted.size // 48),
                  'complex_symbols_compared': int(transmitted.size),
                  'evm_rms_percent': evm_percent,
                  'evm_rms_db': evm_db,
                  'mer_db': -evm_db,
                  'gain_magnitude_db': 20.0 * np.log10(max(abs(gain), 1e-15)),
                  'gain_phase_deg': float(np.degrees(np.angle(gain))),
                  'gain_aligned_evm_rms_percent': aligned_evm_percent,
                  'cumulative_evm_rms_percent': cumulative_evm_percent,
                  'mean_gain_aligned_evm_percent': mean_aligned_evm_percent,
                  'region': 'CRC-valid equalized payload symbols, excluding final OFDM symbol',
                  'estimator': self.estimator_label,
              })
              if self.evm_samples == 1 or self.evm_samples % self.report_interval == 0:
                  print(
                      'EVM: sample={} encoding={} symbols={} raw={:.4f}% aligned={:.4f}% cumulative={:.4f}%'.format(
                          self.evm_samples, encoding, transmitted.size // 48,
                          evm_percent, aligned_evm_percent, cumulative_evm_percent
                      )
                  )

          def stop(self):
              if self.output_file is not None:
                  self.output_file.close()
                  self.output_file = None
              return True
    estimator_label: diagnostic_estimator
    max_records: diagnostic_max_records
    output_path: diagnostic_evm_output
    report_interval: '25'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_11_decode_mac_EVM_0
  id: ieee802_11_decode_mac_EVM
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_debug_0
  id: ieee802_11_frame_equalizer_debug
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_channel_metrics
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.0'
    color1: ("blue", "red")
    color2: ("blue", "red")
    color3: ("blue", "red")
    color4: ("blue", "red")
    color5: ("blue", "red")
    color6: ("blue", "red")
    color7: ("blue", "red")
    color8: ("blue", "red")
    factor8: '100'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,2
    label1: '"SNR"'
    label2: '"CFO"'
    label3: '"Deepest fade"'
    label4: '"Spectral flatness"'
    label5: '"Noise enhancement"'
    label6: '"RMS delay spread"'
    label7: '"CSI correlation"'
    label8: '"CRC success"'
    max: '100'
    min: '-100'
    name: '"Channel Metrics"'
    nconnections: '8'
    type: float
    unit1: '"dB"'
    unit2: '"Hz"'
    unit3: '"dB"'
    unit4: '"dB"'
    unit5: '"dB"'
    unit6: '"ns"'
    unit7: '""'
    unit8: '"%"'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_csi_magnitude
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: '"Relative CSI magnitude"'
    legend: 'False'
    name: '"CSI Magnitude"'
    vlen: '53'
    width1: '2'
    x_axis_label: '"Occupied subcarrier index"'
    x_start: '-26'
    x_step: '1'
    y_axis_label: '"Relative gain (dB)"'
    y_units: '"dB"'
    ymax: '20'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_csi_phase
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    color1: '"red"'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: '"Detrended CSI phase"'
    legend: 'False'
    name: '"CSI Phase Residual"'
    vlen: '53'
    width1: '2'
    x_axis_label: '"Occupied subcarrier index"'
    x_start: '-26'
    x_step: '1'
    y_axis_label: '"Residual phase (rad)"'
    y_units: '"rad"'
    ymax: '3.2'
    ymin: '-3.2'
  states: {}
- name: qtgui_vector_sink_delay_profile
  id: qtgui_vector_sink_f
  parameters:
    color1: '"dark green"'
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: '"Normalized delay power"'
    legend: 'False'
    name: '"Estimated Power Delay Profile"'
    vlen: '64'
    width1: '2'
    x_axis_label: '"Delay"'
    x_start: '0'
    x_step: '0.05'
    x_units: '"us"'
    y_axis_label: '"Normalized power (dB)"'
    y_units: '"dB"'
    ymax: '3'
    ymin: '-80'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: diag2
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: diag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: diag1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: diag2
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: diag
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', virtual_sink_1, '0']
- [epy_channel_estimator_diagnostic, '0', qtgui_vector_sink_csi_magnitude, '0']
- [epy_channel_estimator_diagnostic, '1', qtgui_vector_sink_csi_phase, '0']
- [epy_channel_estimator_diagnostic, '10', qtgui_number_sink_channel_metrics, '7']
- [epy_channel_estimator_diagnostic, '2', qtgui_vector_sink_delay_profile, '0']
- [epy_channel_estimator_diagnostic, '3', qtgui_number_sink_channel_metrics, '0']
- [epy_channel_estimator_diagnostic, '4', qtgui_number_sink_channel_metrics, '1']
- [epy_channel_estimator_diagnostic, '5', qtgui_number_sink_channel_metrics, '2']
- [epy_channel_estimator_diagnostic, '6', qtgui_number_sink_channel_metrics, '3']
- [epy_channel_estimator_diagnostic, '7', qtgui_number_sink_channel_metrics, '4']
- [epy_channel_estimator_diagnostic, '8', qtgui_number_sink_channel_metrics, '5']
- [epy_channel_estimator_diagnostic, '9', qtgui_number_sink_channel_metrics, '6']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_debug_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_EVM_0, diag, virtual_sink_1_0_0, '0']
- [ieee802_11_decode_mac_EVM_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_EVM_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_decode_mac_EVM_0, out, virtual_sink_1_0, '0']
- [ieee802_11_frame_equalizer_debug_0, '0', blocks_vector_to_stream_0, '0']
- [ieee802_11_frame_equalizer_debug_0, '0', ieee802_11_decode_mac_EVM_0, '0']
- [ieee802_11_frame_equalizer_debug_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_1, '0', epy_channel_estimator_diagnostic, '0']
- [virtual_source_1, '0', epy_evm_diagnostic, '0']
- [virtual_source_1_0, '0', epy_channel_estimator_diagnostic, crc_ok]
- [virtual_source_1_0_0, '0', epy_channel_estimator_diagnostic, diag]
- [virtual_source_1_0_0, '0', epy_evm_diagnostic, diag]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
