options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Compare GNU Radio and NPU equalizers on isolated recorded wifi_start candidates.
    generate_options: no_gui
    id: compare_recorded_symbols_grc
    output_language: python
    run_options: run
    title: Recorded Frame Equalizer Symbol Comparison
  states: {}

blocks:
- name: algorithm
  id: variable
  parameters:
    value: __import__('os').environ.get('EQUALIZER_ALGORITHM', 'LS').lower()
  states: {}
- name: algorithm_id
  id: variable
  parameters:
    value: '{''ls'': 0, ''lms'': 1, ''comb'': 2, ''sta'': 3}[algorithm]'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: header_file
  id: variable
  parameters:
    value: __import__('os').environ.get('RECORDED_HEADER', '/home/piloteer/바탕화면/fft_full.iqdata.hdr')
  states: {}
- name: input_file
  id: variable
  parameters:
    value: __import__('os').environ.get('RECORDED_INPUT', '/home/piloteer/바탕화면/fft_full.iqdata')
  states: {}
- name: ltf_words
  id: variable
  parameters:
    comment: Two standard shifted L-LTF vectors for each delimiter frame.
    value: (tuple((0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0)),)*2
  states: {}
- name: marker_payload
  id: variable
  parameters:
    comment: |-
      Two distinct BPSK payload symbols 
      identify each delimiter pair.
    value: tuple([1-(i&1) for i in range(48)] + [i&1 for i in range(48)])
  states: {}
- name: marker_tags
  id: variable
  parameters:
    comment: |-
      Two zero-length BPSK packets, each 
      carrying one marker symbol.
    value: '(lambda p: [gr.tag_utils.python_to_tag((o,p.intern(k),v,p.PMT_NIL)) for o in (0,48) for k,v in (("packet_len",p.from_long(48)),("encoding",p.from_long(0)),("psdu_len",p.from_long(0)),("wifi_start",p.from_double(0.)))])(__import__(''pmt''))'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: Standard 48 legacy data subcarriers.
    value: (list(range(-26,-21))+list(range(-20,-7))+list(range(-6,0))+list(range(1,7))+list(range(8,21))+list(range(22,27)),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    comment: Standard 127-symbol IEEE 802.11 pilot polarity sequence.
    value: tuple((p,p,p,-p) for p in (1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,1,1,-1,1,-1,-1,1,1,-1,1,1,-1,1,1,1,1,1,1,-1,1,1,1,-1,1,1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,1,-1,-1,1,-1,-1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,1,-1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sample_limit
  id: variable
  parameters:
    value: int(__import__('os').environ.get('RECORDED_SAMPLES', '2097152'))
  states: {}
- name: signal_formatter
  id: variable
  parameters:
    comment: GNU Radio's IEEE 802.11 RATE/LENGTH encoder and interleaver.
    value: ieee802_11.signal_field()
  states: {}
- name: blocks_candidate_delimiter_mux
  id: blocks_stream_mux
  parameters:
    comment: Append two standard four-vector delimiter frames to every candidate.
    lengths: (4,8)
    type: complex
    vlen: '64'
  states: {}
- name: blocks_fft_vectors
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Group scalar FFT bins into the 64-bin vectors the equalizers consume;
      recorded wifi_start tags are 64-bin aligned.
    num_items: '64'
    type: complex
  states: {}
- name: blocks_file_meta_source
  id: blocks_file_meta_source
  parameters:
    comment: Recorded scalar frequency-domain FFT output and wifi_start metadata.
    detached: 'True'
    file: input_file
    hdr_file: header_file
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_head
  id: blocks_head
  parameters:
    comment: |-
      Recorded-prefix limit; keep a multiple of 64 
      to preserve whole FFT vectors.
    num_items: sample_limit
    type: complex
  states: {}
- name: blocks_marker_header_payload_mux
  id: blocks_tagged_stream_mux
  parameters:
    comment: |-
      Prefix a standards-generated 
      SIGNAL symbol to each marker payload.
    lengthtagname: packet_len
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: blocks_marker_payload_source
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Repeating pair of delimiter 
      payload decision vectors.
    repeat: 'True'
    tags: marker_tags
    type: byte
    vector: marker_payload
  states: {}
- name: blocks_npu_batch_mux
  id: blocks_stream_mux
  parameters:
    comment: Pad each twelve-vector candidate/delimiter segment to one 16384-sample NPU batch.
    lengths: (12,244)
    type: complex
    vlen: '64'
  states: {}
- name: blocks_npu_decisions_sink
  id: blocks_vector_sink_x
  parameters:
    comment: NPU hard decisions and normalized-symbol csi tags.
    reserve_items: '4096'
    type: byte
    vlen: '48'
  states: {}
- name: blocks_npu_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    comment: Group NPU decisions into OFDM payload symbols.
    num_items: '48'
    type: byte
  states: {}
- name: blocks_npu_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Scalarize each padded NPU batch.
    num_items: '64'
    type: complex
  states: {}
- name: blocks_reference_decisions_sink
  id: blocks_vector_sink_x
  parameters:
    comment: GNU Radio hard decisions and decoded frame tags.
    reserve_items: '4096'
    type: byte
    vlen: '48'
  states: {}
- name: blocks_reference_symbols_debug
  id: blocks_message_debug
  parameters:
    comment: GNU Radio normalized equalized-symbol PDUs.
  states: {}
- name: blocks_zero_padding_source
  id: blocks_vector_source_x
  parameters:
    comment: 244 zero vectors complete every NPU batch.
    repeat: 'True'
    type: complex
    vector: '[0j] * (244*64)'
    vlen: '64'
  states: {}
- name: digital_marker_carrier_allocator
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: Add L-LTF vectors, pilots, and standard carrier placement.
    fft_len: '64'
    len_tag_key: packet_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: pilot_symbols
    sync_words: ltf_words
  states: {}
- name: digital_marker_signal_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map the standards-generated SIGNAL decisions to BPSK.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_marker_signal_header
  id: digital_packet_headergenerator_bb
  parameters:
    comment: |-
      Generate and interleave each 
      marker's IEEE 802.11 SIGNAL field.
    header_formatter: signal_formatter.formatter()
    len_tag_key: packet_len
  states: {}
- name: ieee802_11_frame_equalizer_reference
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(algorithm_id)
    bw: samp_rate
    comment: Standard GNU Radio frame equalizer reference.
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_marker_payload_symbols
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    comment: Map marker labels using the standard per-packet WiFi mapper.
  states: {}
- name: imports
  id: import_
  parameters:
    imports: |-
      import numpy as np
      import pmt
  states: {}
- name: mlir_aie_frame_equalizer_npu
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    comment: Existing NPU GNU Radio adapter.
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}
- name: verify
  id: snippet
  parameters:
    code: |-
      import numpy as np
      import pmt

      # The extractor records source offsets, while the two standard transmitter
      # marker payloads delimit the corresponding compressed equalizer outputs.
      replay = self.zz_candidate_replay
      marker_hard_a = np.asarray(self.marker_payload[:48], dtype=np.int8)
      marker_hard_b = np.asarray(self.marker_payload[48:], dtype=np.int8)

      # Convert a sink's flat tag list into metadata indexed by output-symbol offset.
      def sink_tags(sink):
          result = {}
          for tag in sink.tags():
              offset = int(tag.offset)
              key = pmt.symbol_to_string(tag.key)
              result.setdefault(offset, {})[key] = tag.value
          return result

      # Split the compressed output at each two-marker signature. A four-input-symbol
      # candidate can produce zero or one payload symbol before its delimiter pair.
      def split_candidates(hard, symbols, tags, label):
          if len(hard) != len(symbols):
              raise AssertionError(
                  f'{label} hard/symbol count mismatch: {len(hard)} != {len(symbols)}')
          segments = []
          pending = []
          for index, (decisions, equalized) in enumerate(zip(hard, symbols)):
              frame_bytes = tags.get(index, {}).get('frame bytes')
              pending.append((decisions, equalized, frame_bytes))
              is_delimiter = (
                  len(pending) >= 2
                  and pending[-2][2] is not None
                  and pmt.to_uint64(pending[-2][2]) == 0
                  and np.array_equal(pending[-2][0], marker_hard_a)
                  and pending[-1][2] is not None
                  and pmt.to_uint64(pending[-1][2]) == 0
                  and np.array_equal(pending[-1][0], marker_hard_b))
              if is_delimiter:
                  candidate = pending[:-2]
                  if len(candidate) > 1:
                      raise AssertionError(
                          f'{label} emitted {len(candidate)} candidate symbols before marker '
                          f'{len(segments)}; expected at most one')
                  segments.append(candidate[0][:2] if candidate else None)
                  pending = []
          if pending:
              raise AssertionError(f'{label} output ended without a marker delimiter')
          if len(segments) != len(replay.candidate_offsets):
              raise AssertionError(
                  f'{label} marker count {len(segments)} != replayed candidate count '
                  f'{len(replay.candidate_offsets)}')
          return segments

      # GNU Radio publishes hard decisions as a stream and normalized symbols as PDUs;
      # their order is identical, so zip them before delimiter reconstruction.
      reference_hard = np.asarray(
          self.blocks_reference_decisions_sink.data(), dtype=np.int8).reshape(-1, 48)
      reference_debug = self.blocks_reference_symbols_debug
      reference_symbols = [
          np.asarray(pmt.c32vector_elements(
              pmt.cdr(reference_debug.get_message(i))), dtype=np.complex64)
          for i in range(reference_debug.num_messages())]
      reference = split_candidates(
          reference_hard, reference_symbols,
          sink_tags(self.blocks_reference_decisions_sink), 'GNU Radio')

      # In symbols mode, every NPU output symbol carries its normalized 48-carrier
      # values in the csi tag attached to the same hard-decision vector.
      npu_hard = np.asarray(
          self.blocks_npu_decisions_sink.data(), dtype=np.int8).reshape(-1, 48)
      npu_tags = sink_tags(self.blocks_npu_decisions_sink)
      npu_symbols = []
      for index in range(len(npu_hard)):
          value = npu_tags.get(index, {}).get('csi')
          if value is None:
              raise AssertionError(f'NPU output symbol {index} has no csi tag')
          values = np.asarray(pmt.c32vector_elements(value), dtype=np.complex64)
          if values.size < 48:
              raise AssertionError(
                  f'NPU csi tag {index} has {values.size} values; expected at least 48')
          npu_symbols.append(values[:48])
      actual = split_candidates(npu_hard, npu_symbols, npu_tags, 'NPU')

      # Reproduce the procedural oracle's candidate classifications. The reference
      # magnitude check rejects false wifi_start detections before cross-engine checks.
      matched_actual = []
      matched_reference = []
      matched_evm = []
      gnu_only = 0
      npu_only = 0
      decision_disagreements = 0
      unusable = 0
      for offset, reference_item, actual_item in zip(
              replay.candidate_offsets, reference, actual):
          if (reference_item is not None
                  and np.max(np.abs(reference_item[1])) > 3.0):
              unusable += 1
              continue
          if reference_item is None:
              npu_only += actual_item is not None
              continue
          if actual_item is None:
              gnu_only += 1
              continue
          if not np.array_equal(reference_item[0], actual_item[0]):
              decision_disagreements += 1
              continue
          reference_symbol = reference_item[1]
          actual_symbol = actual_item[1]
          evm = float(np.sqrt(
              np.mean(np.abs(actual_symbol - reference_symbol) ** 2) /
              np.mean(np.abs(reference_symbol) ** 2)))
          gain = np.vdot(reference_symbol, actual_symbol) / np.vdot(
              reference_symbol, reference_symbol)
          matched_reference.append(reference_symbol)
          matched_actual.append(actual_symbol)
          matched_evm.append(evm)
          print(f'  offset={offset} evm={100*evm:.4f}% '
                f'gain={abs(gain):.5f} phase={np.angle(gain):.5f} '
                f'ref_max={np.max(np.abs(reference_symbol)):.3f} '
                f'npu_max={np.max(np.abs(actual_symbol)):.3f}')

      # Report per-candidate accounting first, then enforce one aggregate EVM limit
      # across only mutually decoded candidates with matching hard decisions.

      print(f'recorded candidates: samples={replay.sample_count} '
            f'wifi_start={replay.wifi_start_count} matched={len(matched_actual)} '
            f'GNU_only={gnu_only} NPU_only={npu_only} '
            f'hard_disagreements={decision_disagreements} '
            f'unusable_false_frames={unusable}')
      if not matched_actual:
          raise AssertionError('no mutually decoded recorded frame candidates')
      print(f'matched-frame EVM: median={100*np.median(matched_evm):.4f}% '
            f'min={100*np.min(matched_evm):.4f}% '
            f'max={100*np.max(matched_evm):.4f}%')
      actual_array = np.asarray(matched_actual)
      reference_array = np.asarray(matched_reference)
      error = actual_array - reference_array
      evm = np.sqrt(np.mean(np.abs(error) ** 2) /
                    np.mean(np.abs(reference_array) ** 2))
      gain = np.vdot(reference_array.ravel(), actual_array.ravel()) / np.vdot(
          reference_array.ravel(), reference_array.ravel())
      print(f'recorded FFT matched candidates: rms_evm={100*evm:.5f}% '
            f'max_abs={np.max(np.abs(error)):.7f} gain={abs(gain):.8f} '
            f'phase={np.angle(gain):.8g} rad')
      if not evm < 5e-2:
          raise AssertionError(
              f'recorded FFT matched candidates: EVM {evm} is not below 0.05')
      print(f'frame_equalizer {self.algorithm} recorded GRC comparison passed')
    comment: Reconstruct candidate results at marker boundaries and apply the Python oracle's checks.
    section: main_after_stop
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mux_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mux_in
  states: {}
- name: zz_candidate_replay
  id: epy_block
  parameters:
    _source_code: |-
      from collections import deque
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr


      def _require_build(algorithm):
          supported = {'ls', 'lms', 'comb', 'sta'}
          if algorithm not in supported:
              raise RuntimeError(
                  f'unknown EQUALIZER_ALGORITHM={algorithm!r}; choose LS, LMS, COMB, or STA')
          build = Path('build')
          marker = build / 'frame_equalizer_build_mode.txt'
          artifacts = [build / 'final.xclbin', build / 'insts.bin']
          missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
          if missing:
              raise RuntimeError(
                  'missing frame-equalizer build output(s): ' + ', '.join(missing) +
                  '; run `make compare EQUALIZER_ALGORITHM=' + algorithm.upper() + '`')
          mode = {}
          for line in marker.read_text().splitlines():
              if '=' in line:
                  key, value = line.split('=', 1)
                  mode[key.strip()] = value.strip()
          if mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '1':
              raise RuntimeError(
                  'NPU is not a symbols build (DFRAME_EQUALIZER_OUTPUT_SYMBOLS=' +
                  repr(mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS')) +
                  '); run `make compare EQUALIZER_ALGORITHM=' + algorithm.upper() + '`')
          if mode.get('EQUALIZER_ALGORITHM', '').lower() != algorithm:
              raise RuntimeError(
                  'NPU algorithm is ' + repr(mode.get('EQUALIZER_ALGORITHM', 'unknown')) +
                  ', but the flowgraph selected ' + repr(algorithm) +
                  '; rebuild through `make compare EQUALIZER_ALGORITHM=' +
                  algorithm.upper() + '`')
          if mode.get('ENGINE') not in {'CLASSIC', 'AI'}:
              raise RuntimeError('invalid or missing ENGINE in ' + str(marker))
          if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts):
              raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild')
          instructions = np.fromfile(artifacts[1], dtype=np.uint32)
          for sentinel in (0x13579BDF, 0x2468ACE0):
              count = int(np.count_nonzero(instructions == sentinel))
              if count != 1:
                  raise RuntimeError(
                      f'build/insts.bin has {count} copies of RTP marker {sentinel:#x}; expected 1')


      class candidate_replay(gr.basic_block):
          """Emit the four 64-bin vectors selected by each aligned wifi_start tag."""

          def __init__(self, algorithm='ls'):
              gr.basic_block.__init__(
                  self, name='candidate_replay',
                  in_sig=[(np.complex64, 64)], out_sig=[(np.complex64, 64)])
              self.algorithm = algorithm
              self.wifi_key = pmt.intern('wifi_start')
              # Output offsets describe a new candidate-only stream, so input tags must not
              # propagate automatically; work() recreates only quantized wifi_start tags.
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self._buffer = np.empty((0, 64), dtype=np.complex64)
              self._base = 0
              # _pending holds (vector offset, Q29 CFO) pairs awaiting four vectors;
              # _ready holds complete vectors waiting for scheduler output space.
              self._pending = deque()
              self._ready = deque()
              self.sample_count = 0
              self.wifi_start_count = 0
              self.candidate_offsets = []
              if Path('build/frame_equalizer_build_mode.txt').exists():
                  _require_build(algorithm)

          def start(self):
              # Check again at start so construction before a build cannot bypass the guard.
              _require_build(self.algorithm)
              return True

          def forecast(self, noutput_items, ninputs):
              # Queued vectors can drain without requiring another input item.
              return [0 if self._ready else 1]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              if len(in0):
                  # Buffer vectors because candidate windows can cross scheduler chunks.
                  absolute_start = self.nitems_read(0)
                  if self._base + len(self._buffer) != absolute_start:
                      raise RuntimeError('candidate replay input is not contiguous')
                  tags = self.get_tags_in_range(
                      0, absolute_start, absolute_start + len(in0), self.wifi_key)
                  self._buffer = np.concatenate((self._buffer, np.asarray(in0)))
                  # Round recorded CFO values exactly as the kernel's Q29 metadata ABI does;
                  # stream_to_vector already converted sample offsets to vector indices.
                  self._pending.extend(
                      (int(tag.offset),
                       round(pmt.to_double(tag.value) * (1 << 29)) / float(1 << 29))
                      for tag in tags)
                  self.wifi_start_count += len(tags)
                  self.sample_count = (absolute_start + len(in0)) * 64
                  self.consume(0, len(in0))

                  available_end = self._base + len(self._buffer)
                  # A tag becomes runnable only after all four vectors arrive. Incomplete
                  # tags at EOF are intentionally omitted, matching the procedural oracle.
                  while self._pending and self._pending[0][0] + 4 <= available_end:
                      offset, cfo = self._pending.popleft()
                      self.candidate_offsets.append(offset * 64)
                      begin = offset - self._base
                      for index, vector in enumerate(self._buffer[begin:begin + 4]):
                          self._ready.append((vector.copy(),
                                               cfo if index == 0 else None))
                  # Future tags cannot point into consumed vectors. Keep only the prefix
                  # needed by the earliest incomplete candidate and discard the rest.
                  retain_from = self._pending[0][0] if self._pending else available_end
                  discard = retain_from - self._base
                  if discard:
                      self._buffer = self._buffer[discard:].copy()
                      self._base = retain_from

              count = min(len(output_items[0]), len(self._ready))
              # Reattach wifi_start to the first vector only. Standard blocks append the
              # delimiter frames and fixed-size NPU padding downstream.
              for index in range(count):
                  vector, cfo = self._ready.popleft()
                  output_items[0][index] = vector
                  if cfo is not None:
                      self.add_item_tag(
                          0, self.nitems_written(0) + index, self.wifi_key,
                          pmt.from_double(cfo), pmt.intern('candidate_replay'))
              return count
    algorithm: algorithm
    comment: '*epy: isolate overlapping recorded candidates and validate the build.'
  states: {}

connections:
- [blocks_candidate_delimiter_mux, '0', blocks_npu_batch_mux, '0']
- [blocks_candidate_delimiter_mux, '0', ieee802_11_frame_equalizer_reference, '0']
- [blocks_fft_vectors, '0', zz_candidate_replay, '0']
- [blocks_file_meta_source, '0', blocks_head, '0']
- [blocks_head, '0', blocks_fft_vectors, '0']
- [blocks_marker_header_payload_mux, '0', digital_marker_carrier_allocator, '0']
- [blocks_marker_payload_source, '0', digital_marker_signal_header, '0']
- [blocks_marker_payload_source, '0', ieee802_11_marker_payload_symbols, '0']
- [blocks_npu_batch_mux, '0', blocks_npu_vector_to_stream, '0']
- [blocks_npu_stream_to_vector, '0', blocks_npu_decisions_sink, '0']
- [blocks_npu_vector_to_stream, '0', mlir_aie_frame_equalizer_npu, '0']
- [blocks_zero_padding_source, '0', blocks_npu_batch_mux, '1']
- [digital_marker_carrier_allocator, '0', virtual_sink_0, '0']
- [digital_marker_signal_bpsk, '0', blocks_marker_header_payload_mux, '0']
- [digital_marker_signal_header, '0', digital_marker_signal_bpsk, '0']
- [ieee802_11_frame_equalizer_reference, '0', blocks_reference_decisions_sink, '0']
- [ieee802_11_frame_equalizer_reference, symbols, blocks_reference_symbols_debug, store]
- [ieee802_11_marker_payload_symbols, '0', blocks_marker_header_payload_mux, '1']
- [mlir_aie_frame_equalizer_npu, '0', blocks_npu_stream_to_vector, '0']
- [virtual_source_0, '0', blocks_candidate_delimiter_mux, '1']
- [zz_candidate_replay, '0', blocks_candidate_delimiter_mux, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
