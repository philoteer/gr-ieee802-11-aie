options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Deterministic payload BER benchmark for the active NPU frame-equalizer engine.
    generate_options: no_gui
    id: test_learned_ber_grc
    output_language: python
    run_options: run
    title: Frame Equalizer Learned BER Benchmark
  states: {}

blocks:
- name: batches
  id: variable
  parameters:
    comment: |-
      Number of sixteen-tile 
      NPU batches.
    value: int(__import__('os').environ.get('BER_BATCHES', '10'))
  states: {}
- name: configurations
  id: variable
  parameters:
    comment: 'Report fields: name, RATE, constellation size, LENGTH, encoding.'
    value: (('bpsk',11,2,20,0),('qpsk',10,4,40,2),('qam16',9,16,90,4),('qam64',8,64,180,6))
  states: {}
- name: frame_count
  id: variable
  parameters:
    comment: One frame per NPU tile.
    value: 16*batches
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: ltf_words
  id: variable
  parameters:
    comment: Two standard shifted L-LTF vectors.
    value: (tuple((0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0)),)*2
  states: {}
- name: marker_payload
  id: variable
  parameters:
    comment: Distinct BPSK decisions delimit each compacted tile output.
    value: tuple(1-(i&1) for i in range(48))
  states: {}
- name: marker_tags
  id: variable
  parameters:
    comment: One zero-length BPSK packet repeated after every test frame.
    value: '(lambda p: [gr.tag_utils.python_to_tag((0,p.intern(k),v,p.PMT_NIL)) for k,v in (("packet_len",p.from_long(48)),("encoding",p.from_long(0)),("psdu_len",p.from_long(0)),("wifi_start",p.from_double(0.)))])(__import__(''pmt''))'
  states: {}
- name: noise_amplitudes
  id: variable
  parameters:
    comment: Time-domain AWGN sigma for BPSK, QPSK, 16-QAM, and 64-QAM.
    value: (0.30,0.19,0.09,0.05)
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: Standard 48 legacy data subcarriers.
    value: (list(range(-26,-21))+list(range(-20,-7))+list(range(-6,0))+list(range(1,7))+list(range(8,21))+list(range(22,27)),)
  states: {}
- name: output_file
  id: variable
  parameters:
    value: __import__('os').environ.get('BER_OUTPUT', '')
  states: {}
- name: payload_tags
  id: variable
  parameters:
    comment: Metadata copied onto the standard random-label stream.
    value: '(lambda p,c,n: [gr.tag_utils.python_to_tag((f*384,p.intern(k),v,p.PMT_NIL)) for f in range(n) for k,v in (("packet_len",p.from_long(384)),("encoding",p.from_long(c[f%4][4])),("psdu_len",p.from_long(c[f%4][3])),("wifi_start",p.from_double(0.0)))])(__import__(''pmt''),configurations,frame_count)'
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    comment: Standard 127-symbol IEEE 802.11 pilot polarity sequence.
    value: tuple((p,p,p,-p) for p in (1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,1,1,-1,1,-1,-1,1,1,-1,1,1,-1,1,1,1,1,1,1,-1,1,1,1,-1,1,1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,1,-1,-1,1,-1,-1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,1,-1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: seed
  id: variable
  parameters:
    value: int(__import__('os').environ.get('BER_SEED', '39080211'))
  states: {}
- name: signal_formatter
  id: variable
  parameters:
    comment: GNU Radio's IEEE 802.11 RATE/LENGTH encoder and interleaver.
    value: ieee802_11.signal_field()
  states: {}
- name: analog_bpsk_labels
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: seed+1
    type: byte
  states: {}
- name: analog_bpsk_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitudes[0]
    noise_type: analog.GR_GAUSSIAN
    seed: seed+101
    type: complex
  states: {}
- name: analog_qam16_labels
  id: analog_random_uniform_source_x
  parameters:
    maximum: '16'
    minimum: '0'
    seed: seed+3
    type: byte
  states: {}
- name: analog_qam16_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitudes[2]
    noise_type: analog.GR_GAUSSIAN
    seed: seed+103
    type: complex
  states: {}
- name: analog_qam64_labels
  id: analog_random_uniform_source_x
  parameters:
    maximum: '64'
    minimum: '0'
    seed: seed+4
    type: byte
  states: {}
- name: analog_qam64_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitudes[3]
    noise_type: analog.GR_GAUSSIAN
    seed: seed+104
    type: complex
  states: {}
- name: analog_qpsk_labels
  id: analog_random_uniform_source_x
  parameters:
    maximum: '4'
    minimum: '0'
    seed: seed+2
    type: byte
  states: {}
- name: analog_qpsk_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitudes[1]
    noise_type: analog.GR_GAUSSIAN
    seed: seed+102
    type: complex
  states: {}
- name: blocks_add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_bpsk_head
  id: blocks_head
  parameters:
    num_items: 384*4*batches
    type: byte
  states: {}
- name: blocks_channel_gain
  id: blocks_multiply_const_xx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_channel_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_channel_tag_gate
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
    vlen: '64'
  states: {}
- name: blocks_channel_tag_share
  id: blocks_tag_share
  parameters:
    io_type: complex
    share_type: complex
    vlen: '64'
  states: {}
- name: blocks_fft_scale
  id: blocks_multiply_const_xx
  parameters:
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: blocks_header_payload_mux
  id: blocks_tagged_stream_mux
  parameters:
    comment: Prefix one standard SIGNAL symbol to each eight-symbol payload.
    lengthtagname: packet_len
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: blocks_ifft_scale
  id: blocks_multiply_const_xx
  parameters:
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: blocks_marker_header_payload_mux
  id: blocks_tagged_stream_mux
  parameters:
    comment: Prefix the standards-generated delimiter SIGNAL symbol.
    lengthtagname: packet_len
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: blocks_marker_payload_source
  id: blocks_vector_source_x
  parameters:
    comment: Repeating one-symbol delimiter payload.
    repeat: 'True'
    tags: marker_tags
    type: byte
    vector: marker_payload
  states: {}
- name: blocks_noise_mux
  id: blocks_stream_mux
  parameters:
    lengths: (880,880,880,880)
    num_inputs: '4'
    type: complex
  states: {}
- name: blocks_npu_decisions_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Collect compacted candidate and delimiter decisions with metadata tags.
    reserve_items: '4096'
    type: byte
    vlen: '48'
  states: {}
- name: blocks_npu_stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    comment: Group compacted NPU decisions into OFDM payload symbols.
    num_items: '48'
    type: byte
  states: {}
- name: blocks_npu_vector_to_stream
  id: blocks_vector_to_stream
  parameters:
    comment: Scalarize sixteen-vector tiles for the NPU adapter.
    num_items: '64'
    type: complex
  states: {}
- name: blocks_payload_mux
  id: blocks_stream_mux
  parameters:
    lengths: (384,384,384,384)
    num_inputs: '4'
    type: byte
  states: {}
- name: blocks_payload_tag_carrier
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    tags: payload_tags
    type: byte
    vector: '[0]*(384*frame_count)'
  states: {}
- name: blocks_payload_tag_share
  id: blocks_tag_share
  parameters:
    io_type: byte
    share_type: byte
  states: {}
- name: blocks_payload_truth_sink
  id: blocks_vector_sink_x
  parameters:
    reserve_items: 384*frame_count
    type: byte
  states: {}
- name: blocks_qam16_head
  id: blocks_head
  parameters:
    num_items: 384*4*batches
    type: byte
  states: {}
- name: blocks_qam64_head
  id: blocks_head
  parameters:
    num_items: 384*4*batches
    type: byte
  states: {}
- name: blocks_qpsk_head
  id: blocks_head
  parameters:
    num_items: 384*4*batches
    type: byte
  states: {}
- name: blocks_remove_cp
  id: blocks_keep_m_in_n
  parameters:
    m: '64'
    n: '80'
    offset: '16'
    type: complex
  states: {}
- name: blocks_tile_mux
  id: blocks_stream_mux
  parameters:
    comment: Pack one eleven-vector test frame, one four-vector marker, and one pad vector per tile.
    lengths: (11,4,1)
    num_inputs: '3'
    type: complex
    vlen: '64'
  states: {}
- name: blocks_tile_padding_source
  id: blocks_vector_source_x
  parameters:
    comment: One zero vector completes each sixteen-vector NPU tile.
    repeat: 'True'
    type: complex
    vector: '[0j] * 64'
    vlen: '64'
  states: {}
- name: build_guard
  id: snippet
  parameters:
    code: |-
      from pathlib import Path

      build = Path('build')
      marker = build / 'frame_equalizer_build_mode.txt'
      artifacts = [build / 'final.xclbin', build / 'insts.bin']
      missing = [str(path) for path in [marker, *artifacts] if not path.is_file()]
      if missing:
          raise RuntimeError(
              'missing frame-equalizer build output(s): ' + ', '.join(missing) +
              '; run `make learned-ber ENGINE=CLASSIC` or `ENGINE=AI`')
      self.build_mode = {}
      for line in marker.read_text().splitlines():
          if '=' in line:
              key, value = line.split('=', 1)
              self.build_mode[key.strip()] = value.strip()
      if self.build_mode.get('DFRAME_EQUALIZER_OUTPUT_SYMBOLS') != '0':
          raise RuntimeError('BER benchmark requires a production-mode build')
      if self.build_mode.get('EQUALIZER_ALGORITHM') not in {'LS', 'LMS', 'COMB', 'STA', 'CNN'}:
          raise RuntimeError('invalid or missing EQUALIZER_ALGORITHM in ' + str(marker))
      if self.build_mode.get('ENGINE') not in {'CLASSIC', 'AI'}:
          raise RuntimeError('invalid or missing ENGINE in ' + str(marker))
      if marker.stat().st_mtime_ns < max(path.stat().st_mtime_ns for path in artifacts):
          raise RuntimeError(str(marker) + ' is older than the NPU artifacts; rebuild')
    comment: Reject stale or incompatible NPU images before block construction.
    section: init_before_blocks
  states: {}
- name: channels_fading
  id: channels_selective_fading_model
  parameters:
    K: '8.0'
    LOS: 'True'
    N: '8'
    delays: (0.0,3.0,8.0)
    fDTs: 40.0/samp_rate
    mags: (1.0,0.35,0.2)
    ntaps: '16'
    seed: seed+50
  states: {}
- name: channels_hardware_impairments
  id: channels_impairments
  parameters:
    beta: '0.018'
    freq_offset: '0.0'
    gamma: '0.0'
    i_ofs: '0.0'
    magbal: '0.25'
    phase_noise_mag: '0.0'
    phasebal: '3.0'
    q_ofs: '0.0'
  states: {}
- name: digital_carrier_allocator
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: Add L-LTF vectors, pilots, guards, and standard carrier placement.
    fft_len: '64'
    len_tag_key: packet_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: pilot_symbols
    sync_words: ltf_words
  states: {}
- name: digital_cyclic_prefixer
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '16'
    input_size: '64'
    tagname: '""'
  states: {}
- name: digital_marker_carrier_allocator
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: Add L-LTF vectors, pilots, and standard delimiter carrier placement.
    fft_len: '64'
    len_tag_key: packet_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: pilot_symbols
    sync_words: ltf_words
  states: {}
- name: digital_marker_signal_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map the delimiter SIGNAL decisions to BPSK.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_marker_signal_header
  id: digital_packet_headergenerator_bb
  parameters:
    comment: Generate the delimiter's valid zero-length SIGNAL field.
    header_formatter: signal_formatter.formatter()
    len_tag_key: packet_len
  states: {}
- name: digital_signal_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map standards-generated SIGNAL decisions to BPSK.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_signal_header
  id: digital_packet_headergenerator_bb
  parameters:
    comment: Generate and interleave each IEEE 802.11 SIGNAL field.
    header_formatter: signal_formatter.formatter()
    len_tag_key: packet_len
  states: {}
- name: fft_fft
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_ifft
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: ieee802_11_marker_payload_symbols
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    comment: Map delimiter labels through the standard WiFi mapper.
  states: {}
- name: ieee802_11_payload_symbols
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    comment: Per-packet standard BPSK/QPSK/QAM mapper selected by encoding tags.
  states: {}
- name: mlir_aie_frame_equalizer_npu
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    comment: Existing NPU GNU Radio adapter.
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}
- name: report
  id: snippet
  parameters:
    code: |-
      # Rebuild per-tile results after the stream stops.
      #
      # The NPU adapter compacts away empty tile outputs. Every transmitted frame
      # is followed by a standards-generated zero-length delimiter frame; splitting
      # at those decisions recovers one result segment per physical tile.
      import json
      from pathlib import Path
      import numpy as np
      import pmt

      hard = np.asarray(self.blocks_npu_decisions_sink.data(), dtype=np.uint8).reshape(-1, 48)
      truths = np.asarray(self.blocks_payload_truth_sink.data(), dtype=np.uint8)
      if truths.size != 384 * self.frame_count:
          raise AssertionError(
              f'truth stream has {truths.size} labels; expected {384 * self.frame_count}')
      truths = truths.reshape(self.frame_count, 8, 48)
      marker_hard = np.asarray(self.marker_payload, dtype=np.uint8)

      # Index adapter metadata by output-symbol offset.
      tags = {}
      for tag in self.blocks_npu_decisions_sink.tags():
          offset = int(tag.offset)
          key = pmt.symbol_to_string(tag.key)
          tags.setdefault(offset, {})[key] = tag.value

      # Split compacted output at each marker frame.
      segments = []
      pending = []
      for index, decisions in enumerate(hard):
          frame_bytes = tags.get(index, {}).get('frame bytes')
          is_marker = (frame_bytes is not None and
                       pmt.to_uint64(frame_bytes) == 0 and
                       np.array_equal(decisions, marker_hard))
          if is_marker:
              segments.append(pending)
              pending = []
          else:
              pending.append(index)
      if pending:
          raise AssertionError('NPU output ended without a marker delimiter')
      if len(segments) != self.frame_count:
          raise AssertionError(
              f'marker count {len(segments)} != transmitted frame count {self.frame_count}')

      # Accumulators hold received errors/counts followed by transmitted counts.
      # Invalid RATE, LENGTH, or output length is reported as a packet miss. The
      # combined rates additionally count every bit and symbol in that packet wrong.
      bit_widths = {'bpsk': 1, 'qpsk': 2, 'qam16': 4, 'qam64': 6}
      totals = {name: np.zeros(6, np.int64) for name in bit_widths}
      dropped = {name: 0 for name in bit_widths}
      frames = {name: 0 for name in bit_widths}
      for frame_index, (segment, truth) in enumerate(zip(segments, truths)):
          name, rate, modulation, length, encoding = self.configurations[frame_index % 4]
          frame_tags = [tags[index] for index in segment
                        if 'frame bytes' in tags.get(index, {})]
          tag_valid = len(frame_tags) == 1
          if tag_valid:
              tag = frame_tags[0]
              tag_valid = ('encoding' in tag and
                           (pmt.to_uint64(tag['frame bytes']),
                            pmt.to_uint64(tag['encoding'])) == (length, encoding))
          frame_valid = tag_valid and len(segment) == 8
          bits_per_symbol = bit_widths[name]
          expected = truth.reshape(-1)
          total_bits = expected.size * bits_per_symbol
          if frame_valid:
              actual = hard[segment].reshape(-1)
              xor = actual ^ expected
              bit_errors = sum(int(np.count_nonzero((xor >> bit) & 1))
                               for bit in range(bits_per_symbol))
              symbol_errors = int(np.count_nonzero(actual != expected))
              received_bits = total_bits
              received_symbols = expected.size
          else:
              bit_errors = 0
              symbol_errors = 0
              received_bits = 0
              received_symbols = 0
          totals[name] += (bit_errors, symbol_errors, received_bits,
                           received_symbols, total_bits, expected.size)
          dropped[name] += int(not frame_valid)
          frames[name] += 1

      report = {
          'engine': self.build_mode.get('ENGINE'),
          'algorithm': self.build_mode.get('EQUALIZER_ALGORITHM'),
          'seed': self.seed,
          'batches': self.batches,
          'constellation_source': 'installed ieee802_11 Python bindings',
          'models': {},
      }
      for name, values in totals.items():
          (bit_errors, symbol_errors, received_bits, received_symbols,
           bits, symbols) = map(int, values)
          missed_packets = dropped[name]
          combined_bit_errors = bit_errors + bits - received_bits
          combined_symbol_errors = symbol_errors + symbols - received_symbols
          report['models'][name] = {
              'ber_received': bit_errors / received_bits if received_bits else None,
              'ber_combined': combined_bit_errors / bits,
              'packet_miss_rate': missed_packets / frames[name],
              'ser_received': symbol_errors / received_symbols if received_symbols else None,
              'ser_combined': combined_symbol_errors / symbols,
              'received_bit_errors': bit_errors,
              'received_bits': received_bits,
              'combined_bit_errors': combined_bit_errors,
              'total_bits': bits,
              'missed_packets': missed_packets,
              'packets': frames[name],
          }
      rendered = json.dumps(report, indent=2)
      print(rendered)
      if self.output_file:
          Path(self.output_file).write_text(rendered + '\n')
    comment: Reconstruct tile results at marker boundaries and emit the BER JSON report.
    section: main_after_stop
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rx_until_fft
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx_impaired
  states: {}
- name: virtual_sink_channel_tags
  id: virtual_sink
  parameters:
    comment: Preserve the transmitter tags for restoration after the channel.
    stream_id: channel_tag_reference
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rx_until_fft
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: tx_impaired
  states: {}
- name: virtual_source_channel_tags
  id: virtual_source
  parameters:
    comment: Restore transmitter tags after the time-domain channel and FFT.
    stream_id: channel_tag_reference
  states: {}

connections:
- [analog_bpsk_labels, '0', blocks_bpsk_head, '0']
- [analog_bpsk_noise, '0', blocks_noise_mux, '0']
- [analog_qam16_labels, '0', blocks_qam16_head, '0']
- [analog_qam16_noise, '0', blocks_noise_mux, '2']
- [analog_qam64_labels, '0', blocks_qam64_head, '0']
- [analog_qam64_noise, '0', blocks_noise_mux, '3']
- [analog_qpsk_labels, '0', blocks_qpsk_head, '0']
- [analog_qpsk_noise, '0', blocks_noise_mux, '1']
- [blocks_add_noise, '0', virtual_sink_0_0, '0']
- [blocks_bpsk_head, '0', blocks_payload_mux, '0']
- [blocks_channel_gain, '0', blocks_add_noise, '0']
- [blocks_channel_stream_to_vector, '0', fft_fft, '0']
- [blocks_channel_tag_gate, '0', blocks_channel_tag_share, '0']
- [blocks_channel_tag_share, '0', virtual_sink_0, '0']
- [blocks_fft_scale, '0', blocks_channel_tag_gate, '0']
- [blocks_header_payload_mux, '0', digital_carrier_allocator, '0']
- [blocks_ifft_scale, '0', digital_cyclic_prefixer, '0']
- [blocks_marker_header_payload_mux, '0', digital_marker_carrier_allocator, '0']
- [blocks_marker_payload_source, '0', digital_marker_signal_header, '0']
- [blocks_marker_payload_source, '0', ieee802_11_marker_payload_symbols, '0']
- [blocks_noise_mux, '0', blocks_add_noise, '1']
- [blocks_npu_stream_to_vector, '0', blocks_npu_decisions_sink, '0']
- [blocks_npu_vector_to_stream, '0', mlir_aie_frame_equalizer_npu, '0']
- [blocks_payload_mux, '0', blocks_payload_tag_share, '0']
- [blocks_payload_tag_carrier, '0', blocks_payload_tag_share, '1']
- [blocks_payload_tag_share, '0', blocks_payload_truth_sink, '0']
- [blocks_payload_tag_share, '0', digital_signal_header, '0']
- [blocks_payload_tag_share, '0', ieee802_11_payload_symbols, '0']
- [blocks_qam16_head, '0', blocks_payload_mux, '2']
- [blocks_qam64_head, '0', blocks_payload_mux, '3']
- [blocks_qpsk_head, '0', blocks_payload_mux, '1']
- [blocks_remove_cp, '0', blocks_channel_stream_to_vector, '0']
- [blocks_tile_mux, '0', blocks_npu_vector_to_stream, '0']
- [blocks_tile_padding_source, '0', blocks_tile_mux, '2']
- [channels_fading, '0', blocks_channel_gain, '0']
- [channels_hardware_impairments, '0', channels_fading, '0']
- [digital_carrier_allocator, '0', fft_ifft, '0']
- [digital_carrier_allocator, '0', virtual_sink_channel_tags, '0']
- [digital_cyclic_prefixer, '0', channels_hardware_impairments, '0']
- [digital_marker_carrier_allocator, '0', blocks_tile_mux, '1']
- [digital_marker_signal_bpsk, '0', blocks_marker_header_payload_mux, '0']
- [digital_marker_signal_header, '0', digital_marker_signal_bpsk, '0']
- [digital_signal_bpsk, '0', blocks_header_payload_mux, '0']
- [digital_signal_header, '0', digital_signal_bpsk, '0']
- [fft_fft, '0', blocks_fft_scale, '0']
- [fft_ifft, '0', blocks_ifft_scale, '0']
- [ieee802_11_marker_payload_symbols, '0', blocks_marker_header_payload_mux, '1']
- [ieee802_11_payload_symbols, '0', blocks_header_payload_mux, '1']
- [mlir_aie_frame_equalizer_npu, '0', blocks_npu_stream_to_vector, '0']
- [virtual_source_0, '0', blocks_tile_mux, '0']
- [virtual_source_1, '0', blocks_remove_cp, '0']
- [virtual_source_channel_tags, '0', blocks_channel_tag_share, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
