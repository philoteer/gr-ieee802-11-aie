options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: stage1
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'True'
    extra_dict: pmt.make_dict()
    file: ./stage1.out
    max_seg_size: '1000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/piloteer/바탕화면/output_head_short.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '127.0'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: "#!/usr/bin/env python\n# -*- coding: utf-8 -*-\n#\n# Copyright 2026 gr-mlir_aie author.\n#\n# SPDX-License-Identifier: GPL-3.0-or-later\n#\n\nimport numpy as np\nfrom gnuradio import gr\n\nfrom aie.dialects.aie import *\nfrom aie.extras.context import mlir_mod_ctx\nfrom aie.iron import Program, Runtime, Worker, ObjectFifo\nfrom aie.iron.placers import SequentialPlacer\nfrom aie.iron.controlflow import range_\n\nimport aie.iron as iron\nfrom aie.utils import NPUKernel, DefaultNPURuntime, get_current_device\n\nDEV = iron.get_current_device()\nDTYPE=np.int32\n\nclass mlir_aie_python_int32(gr.basic_block):\n    \"\"\"\n    docstring for block mlir_aie_python_int32\n    \"\"\"\n    def __init__(self, path_xclbin=\"/media/piloteer/SAMSUNG_EXT/gr-ieee802-11-mlir-aie/aie-kernel-src/build/final.xclbin\",path_insts_bin=\"/media/piloteer/SAMSUNG_EXT/gr-ieee802-11-mlir-aie/aie-kernel-src/build/insts.bin\", VECTOR_SIZE = 4096):\n        gr.basic_block.__init__(self,\n            name=\"mlir_aie_python_int32\",\n            in_sig=[DTYPE, ],\n            out_sig=[DTYPE, ])\n            \n        npu_kernel = NPUKernel(\n            path_xclbin,\n            path_insts_bin,\n            kernel_name=\"MLIR_AIE\",\n        )\n         \n        self.kernel_handle = DefaultNPURuntime.load(npu_kernel)\n        self.out_buf = iron.zeros(VECTOR_SIZE, dtype=DTYPE)\n        self.VECTOR_SIZE = VECTOR_SIZE\n\n    #TODO implement forecast()\n    def forecast(self, noutput_items, ninputs):\n        #ninput_items_required = [min(self.VECTOR_SIZE, noutput_items)] * ninputs\n        ninput_items_required = [noutput_items] * ninputs   \n        return ninput_items_required\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        \n        n_input_items = len(in0)\n        n_output_items = len(out0)\n        \n        available_items = min(n_input_items, n_output_items)\n        n_chunks = available_items // self.VECTOR_SIZE\n\n        if n_chunks == 0:\n            return 0\n\n        for i in range(n_chunks):\n            start_idx = i * self.VECTOR_SIZE\n            end_idx = start_idx + self.VECTOR_SIZE\n            \n            current_in_tensor = iron.tensor(in0[start_idx:end_idx], dtype=DTYPE)\n            buffers = [current_in_tensor, self.out_buf] \n            DefaultNPURuntime.run(self.kernel_handle, buffers)                    \n            out0[start_idx:end_idx] = self.out_buf.numpy()\n        \n        total_processed = n_chunks * self.VECTOR_SIZE        \n        self.consume_each(total_processed)\n        \n        return total_processed\n\n"
    path_insts_bin: '"/media/piloteer/SAMSUNG_EXT/gr-ieee802-11-mlir-aie/aie-kernel-src/build/insts.bin"'
    path_xclbin: '"/media/piloteer/SAMSUNG_EXT/gr-ieee802-11-mlir-aie/aie-kernel-src/build/final.xclbin"'
  states: {state: disabled}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: mlir_aie_cbfloat_to_complex64_0
  id: mlir_aie_cbfloat_to_complex64
  parameters: {}
  states: {state: disabled}
- name: mlir_aie_complex64_to_cbfloat_0
  id: mlir_aie_complex64_to_cbfloat
  parameters: {}
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: 1_I
    label2: 1_Q
    label3: 2_I
    label4: 2_Q
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [epy_block_0, '0', mlir_aie_cbfloat_to_complex64_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_file_meta_sink_0, '0']
- [mlir_aie_cbfloat_to_complex64_0, '0', qtgui_time_sink_x_1, '0']
- [mlir_aie_complex64_to_cbfloat_0, '0', epy_block_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cbfloat_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
