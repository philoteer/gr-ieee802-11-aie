options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_command: bash -c 'export LD_LIBRARY_PATH="$(dirname "$2")/../../../../gr-foo-fixed/build/lib${{LD_LIBRARY_PATH:+:$LD_LIBRARY_PATH}}"; exec "$1" -u "$2"' -- {python} {filename}
    run_options: run
  states: {}

blocks:
- name: dataset
  id: parameter
  parameters:
    comment: Optional SigMF prefix override, without the -data or -meta suffix.
    label: Dataset
    type: str
    value: ''
  states: {}
- name: input_path
  id: variable
  parameters:
    comment: Use the command-line dataset when supplied, otherwise the enabled file_path.
    value: dataset or file_path
  states: {}
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in base/test/threshold_cf.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/threshold_cf/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test_awgn_15db.sigmf"
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2417000000.0'
  states: {}
- name: gain_BB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: gain_IF
  id: variable
  parameters:
    value: '32'
  states: {}
- name: gain_RF
  id: variable
  parameters:
    value: '14'
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Standalone threshold kernel built by the local Makefile.
    value: str(__import__("pathlib").Path(globals().get("__file__", "base/test/threshold_cf/wifi_rx.py")).resolve().parent / "build")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: vector_size
  id: variable
  parameters:
    comment: VECTOR_SIZE uses fixed 1024-sample AIE tiles.
    value: '16384'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: mlir_aie_complex64_to_cint32_0
  id: mlir_aie_complex64_to_cint32
  parameters:
    fractional_bits: '24'
    integer_bits: '7'
    safe: 'False'
  states: {}
- name: mlir_aie_float32_to_int32_Q_0
  id: mlir_aie_float32_to_int32_Q
  parameters:
    fractional_bits: '23'
    integer_bits: '8'
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0
  id: mlir_aie_mlir_aie_cpp_80211_magsq_and_div
  parameters:
    VECTOR_SIZE: vector_size
    kernel_name: MLIR_AIE
    num_slots: '2'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: input_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_moving_average_xx_0, '0', mlir_aie_float32_to_int32_Q_0, '0']
- [blocks_moving_average_xx_1, '0', mlir_aie_complex64_to_cint32_0, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [mlir_aie_complex64_to_cint32_0, '0', mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '0']
- [mlir_aie_float32_to_int32_Q_0, '0', mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '1']
- [mlir_aie_mlir_aie_cpp_80211_magsq_and_div_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
