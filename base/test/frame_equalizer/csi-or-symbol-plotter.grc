options:
  parameters:
    category: Custom
    description: Compare GNU Radio and AIE frame-equalizer decision streams from recorded FFT output. The x-axis is decision index, not RF sample time.
    generate_options: qt_gui
    id: frame_equalizer_realtime_test
    output_language: python
    run_options: run
    title: Frame Equalizer Decision Comparison
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_meta_source_1
  id: blocks_file_meta_source
  parameters:
    detached: 'True'
    file: /home/piloteer/바탕화면/fft_full.iqdata
    hdr_file: /home/piloteer/바탕화면/fft_full.iqdata.hdr
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'True'
    single_key: '"wifi_start"'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '52'
    type: complex
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: ieee802_11_extract_csi_0
  id: ieee802_11_extract_csi
  parameters: {}
  states: {}
- name: mlir_aie_mlir_aie_cpp_equalizer_test_0
  id: mlir_aie_mlir_aie_cpp_equalizer_test
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '1'
    path_insts_bin: '"build/insts.bin"'
    path_xclbin: '"build/final.xclbin"'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_meta_source_1, '0', blocks_probe_rate_0, '0']
- [blocks_file_meta_source_1, '0', blocks_tag_gate_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [blocks_tag_gate_0, '0', mlir_aie_mlir_aie_cpp_equalizer_test_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [ieee802_11_decode_mac_0, out, ieee802_11_extract_csi_0, pdu in]
- [ieee802_11_extract_csi_0, '0', blocks_vector_to_stream_0, '0']
- [mlir_aie_mlir_aie_cpp_equalizer_test_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
