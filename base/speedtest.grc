options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_path
  id: variable
  parameters:
    value: '"data/raw_capture/206.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: /home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/latency_profile/null_kernel/build/insts.bin
    path_xclbin: /home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/latency_profile/null_kernel/build/final.xclbin
    weights_path: ''''''
  states: {state: disabled}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
