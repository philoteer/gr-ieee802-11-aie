options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/wifi_rx.py")).resolve().parents[2] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '2417000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data_dir + "/tmp_out/orig.pcap"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: epy_block_energy_logger
  id: epy_block
  parameters:
    _source_code: |
      import atexit
      import csv
      from pathlib import Path
      import threading
      import time

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Sample energy until finish_logging() is called after top_block.wait()."""

          def __init__(self, csv_path="original_energy.csv", interval=0.5,
                       rapl_path="/sys/class/powercap/intel-rapl:0",
                       power_supply_path="/sys/class/power_supply"):
              gr.sync_block.__init__(self, name="Run Energy Logger",
                                     in_sig=[np.complex64], out_sig=None)
              if interval < 0.05:
                  raise ValueError("Energy sampling interval must be at least 0.05 s")
              self.csv_path = Path(csv_path)
              self.interval = interval
              self.rapl = Path(rapl_path)
              self.supplies = Path(power_supply_path)
              self.samples = 0
              self._done = threading.Event()
              self._thread = None
              self._file = None
              self._error = None
              self._previous = None
              self._energy_j = 0.0

          @staticmethod
          def _read(path):
              return path.read_text().strip()

          def _battery_reading(self):
              # ACPI sysfs is also the source of sensors' BAT0-acpi power1.
              online = any(int(self._read(path / "online")) != 0
                           for path in self._external)
              status = self._read(self._battery / "status")
              unplugged = not online and status == "Discharging"
              if not unplugged:
                  return online, status, "", ""
              watts = int(self._read(self._battery / "power_now")) / 1e6
              joules = int(self._read(self._battery / "energy_now")) * 0.0036
              return online, status, watts, joules

          def _sample(self, phase):
              counter = int(self._read(self.rapl / "energy_uj"))
              now = time.monotonic_ns()
              wall = time.time_ns()
              online, status, system_w, battery_j = self._battery_reading()
              power_w = ""
              if self._previous is None:
                  self._start_ns = now
              else:
                  previous_ns, previous_counter = self._previous
                  delta = counter - previous_counter
                  if delta < 0:
                      delta += self._range_uj
                  self._energy_j += delta / 1e6
                  power_w = delta * 1000.0 / (now - previous_ns)
              self._previous = now, counter
              self._writer.writerow({
                  "phase": phase,
                  "unix_time_ns": wall,
                  "elapsed_s": (now - self._start_ns) / 1e9,
                  "samples_processed": self.samples,
                  "rapl_domain": self._domain,
                  "rapl_energy_uj": counter,
                  "rapl_max_energy_range_uj": self._range_uj,
                  "soc_energy_j": self._energy_j,
                  "soc_power_w": power_w,
                  "ac_online": int(online),
                  "battery_status": status,
                  "system_power_w": system_w,
                  "battery_energy_j": battery_j,
              })
              self._file.flush()

          def start(self):
              self.csv_path = Path(self.csv_path)
              self.rapl = Path(self.rapl)
              self.supplies = Path(self.supplies)
              self.samples = 0
              self._previous = None
              self._energy_j = 0.0
              self._error = None
              self._done.clear()
              self._range_uj = int(self._read(self.rapl / "max_energy_range_uj"))
              self._domain = self._read(self.rapl / "name")
              batteries = [p for p in self.supplies.iterdir()
                           if (p / "type").exists() and self._read(p / "type") == "Battery"]
              if len(batteries) != 1:
                  raise RuntimeError("Energy logger requires exactly one battery")
              self._battery = batteries[0]
              self._external = [p for p in self.supplies.iterdir()
                                if p != self._battery and (p / "online").exists()]
              if not self._external:
                  raise RuntimeError("No external power supply online indicator found")
              self.csv_path.parent.mkdir(parents=True, exist_ok=True)
              self._file = self.csv_path.open("w", newline="")
              self._writer = csv.DictWriter(self._file, fieldnames=[
                  "phase", "unix_time_ns", "elapsed_s", "samples_processed",
                  "rapl_domain", "rapl_energy_uj", "rapl_max_energy_range_uj",
                  "soc_energy_j", "soc_power_w", "ac_online", "battery_status",
                  "system_power_w", "battery_energy_j"])
              self._writer.writeheader()
              try:
                  self._sample("start")
              except Exception:
                  self._file.close()
                  self._file = None
                  raise
              self._thread = threading.Thread(target=self._monitor, daemon=True)
              self._thread.start()
              atexit.register(self.finish_logging)
              return True

          def _monitor(self):
              while not self._done.wait(self.interval):
                  try:
                      self._sample("sample")
                  except Exception as error:
                      self._error = error
                      return

          def finish_logging(self):
              # The IQ branch can finish before the decoder. Do not finalize in
              # block.stop(): the flowgraph's after-stop snippet calls this after wait().
              if self._file is None:
                  return
              self._done.set()
              self._thread.join()
              try:
                  if self._error is not None:
                      raise RuntimeError("Energy sampling failed") from self._error
                  self._sample("end")
              finally:
                  self._file.close()
                  self._file = None
                  atexit.unregister(self.finish_logging)

          def work(self, input_items, output_items):
              count = len(input_items[0])
              self.samples += count
              return count
    comment: Logs through top_block.wait(); paired with energy_logger_finish snippet.
    csv_path: data_dir + "/tmp_out/original_energy.csv"
    interval: '0.5'
    rapl_path: '"/sys/class/powercap/intel-rapl:0"'
    power_supply_path: '"/sys/class/power_supply"'
  states: {}
- name: energy_logger_finish
  id: snippet
  parameters:
    comment: Finish after all processing, on EOF or SIGINT/SIGTERM.
    section: main_after_stop
    code: self.epy_block_energy_logger.finish_logging()
  states: {}
- name: epy_block_iq_tag_sink
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          def __init__(self, frequency_callback=lambda value: None):
              gr.sync_block.__init__(
                  self, name="IQ Tag Frequency Retuner", in_sig=[np.complex64], out_sig=None)
              self.frequency_callback = frequency_callback
              self.frequency_key = pmt.intern("rx_freq")

          def work(self, input_items, output_items):
              count = len(input_items[0])
              for tag in self.get_tags_in_window(0, 0, count, self.frequency_key):
                  self.frequency_callback(pmt.to_double(tag.value))
              return count
    frequency_callback: 'lambda value: self.set_freq(value)'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_divide_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_frame_equalizer_0, symbols, pdu_pdu_to_tagged_stream_0, pdus]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', epy_block_iq_tag_sink, '0']
- [virtual_source_0, '0', epy_block_energy_logger, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
