options:
  parameters:
    category: Custom
    description: NPU PHY energy measurement on the shared 20 MHz stress-test capture.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_command: bash -c 'export LD_LIBRARY_PATH="$(dirname "$2")/../../../../gr-foo-fixed/build/lib${{LD_LIBRARY_PATH:+:$LD_LIBRARY_PATH}}"; exec "$1" -u "$2"' -- {python} {filename}
    run_options: run
    title: NPU Energy Experiment
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy/NPU.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/NPU/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    comment: Build artifacts for the base 16-tile, 16384-sample NPU PHY.
    value: str(__import__("pathlib").Path(data_dir).parents[1] / "base" / "kernel" / "build")
  states: {state: disabled}
- name: kernel_dir
  id: variable
  parameters:
    comment: Build artifacts for the base 16-tile, 16384-sample NPU PHY.
    value: str(__import__("pathlib").Path(data_dir).parents[1] / "AI-model-CNN-Channel-est" / "kernel" / "build")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data_dir + "/tmp_out/npu.pcap"
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: energy_logger_finish
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.finish_logging()
    comment: Finish after all processing, on EOF or SIGINT/SIGTERM.
    section: main_after_stop
  states: {}
- name: energy_logger_prepare
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.begin_logging()
    section: main_after_init
  states: {}
- name: energy_logger_start
  id: snippet
  parameters:
    code: 'self.epy_block_energy_logger.start_monitoring(lambda: self.mlir_aie_sigmf_tag_injector_0.nitems_written(0))'
    section: main_after_start
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      #
      # Copyright 2026 gr-mlir_aie author.
      #
      # SPDX-License-Identifier: GPL-3.0-or-later
      #


      import numpy as np
      from gnuradio import gr
      import pmt

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel
      import os
      import tempfile


      INPUT_DTYPE = np.int32
      OUTPUT_DTYPE = np.int8
      METADATA_DTYPE = np.int32

      MAX_TAGS_PER_TILE = 16
      N_TILES = 4
      CSI_SIZE = 64
      Q16_15_SCALE = 1.0 / (1 << 15)

      # These aligned dtypes reproduce tag_metadata and tile_metadata from the C++
      # block, including the uint64 fields and the CSI complex pairs.
      CSI_DTYPE = np.dtype([
          ("real", np.int32),
          ("imag", np.int32),
      ], align=True)
      TAG_METADATA_DTYPE = np.dtype([
          ("offset", np.int32),
          ("frame_start", np.uint32),
          ("frame_bytes", np.uint64),
          ("encoding", np.uint64),
          ("snr_linear", np.uint64),
          ("center_frequency_mhz", np.uint32),
          ("frequency_offset", np.int32),
          ("beta", np.int32),
          ("csi", CSI_DTYPE, (CSI_SIZE,)),
      ], align=True)
      TILE_METADATA_DTYPE = np.dtype([
          ("output_length", np.int32),
          ("tag_count", np.int32),
          ("tags", TAG_METADATA_DTYPE, (MAX_TAGS_PER_TILE,)),
      ], align=True)
      METADATA_WORDS = N_TILES * TILE_METADATA_DTYPE.itemsize // np.dtype(
          METADATA_DTYPE).itemsize


      class mlir_aie_python_80211_phy(gr.basic_block):
          """Run the MLIR-AIE 802.11 PHY and recreate frame equalizer tags."""

          def __init__(self,
                       path_xclbin="kernel/build/final.xclbin",
                       path_insts_bin="kernel/build/insts.bin",
                       kernel_name="MLIR_AIE",
                       VECTOR_SIZE=4096,
                       nominal_frequency=2.417e9):
              gr.basic_block.__init__(
                  self,
                  name="mlir_aie_python_80211_phy",
                  in_sig=[INPUT_DTYPE],
                  out_sig=[OUTPUT_DTYPE],
              )

              center_frequency_mhz = round(nominal_frequency / 1e6)
              instructions = np.fromfile(path_insts_bin, dtype=np.uint32).copy()
              for marker, value in ((0x13579BDF, center_frequency_mhz), (0x2468ACE0, round(20.0 / center_frequency_mhz * (1 << 30)))):
                  matches = np.flatnonzero(instructions == marker)
                  if len(matches) != 1:
                      raise RuntimeError("center-frequency RTP marker is missing or ambiguous")
                  instructions[matches[0]] = np.uint32(value)
              self.rtp_dir = tempfile.TemporaryDirectory()
              patched_insts = os.path.join(self.rtp_dir.name, "insts.bin")
              instructions.tofile(patched_insts)

              npu_kernel = NPUKernel(
                  path_xclbin,
                  patched_insts,
                  kernel_name=kernel_name,
              )
              self.kernel_handle = DefaultNPURuntime.load(npu_kernel)
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=OUTPUT_DTYPE)
              self.out_meta_buf = iron.zeros(METADATA_WORDS, dtype=METADATA_DTYPE)
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // N_TILES
              self.nominal_frequency = nominal_frequency

              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.tag_srcid = pmt.intern("frame_equalizer")
              self.tag_keys = {
                  "frame_bytes": pmt.intern("frame bytes"),
                  "encoding": pmt.intern("encoding"),
                  "snr": pmt.intern("snr"),
                  "nominal_frequency": pmt.intern("nominal frequency"),
                  "frequency_offset": pmt.intern("frequency offset"),
                  "beta": pmt.intern("beta"),
                  "csi": pmt.intern("csi"),
              }

          def forecast(self, noutput_items, ninputs):
              return [noutput_items] * ninputs

          def set_nominal_frequency(self, nominal_frequency):
              self.nominal_frequency = nominal_frequency

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_chunks = min(len(in0), len(out0)) // self.VECTOR_SIZE

              if n_chunks == 0:
                  return 0

              output_abs_start = self.nitems_written(0)
              total_produced = 0

              for chunk_idx in range(n_chunks):
                  input_start = chunk_idx * self.VECTOR_SIZE
                  input_end = input_start + self.VECTOR_SIZE
                  current_in_tensor = iron.tensor(
                      in0[input_start:input_end], dtype=INPUT_DTYPE)

                  DefaultNPURuntime.run(
                      self.kernel_handle,
                      [current_in_tensor, self.out_buf, self.out_meta_buf],
                  )

                  npu_output = self.out_buf.numpy()
                  metadata = self.out_meta_buf.numpy().view(
                      TILE_METADATA_DTYPE).reshape(N_TILES)

                  for tile_idx, tile_meta in enumerate(metadata):
                      tile_len = max(
                          0, min(int(tile_meta["output_length"]), self.TILE_SIZE))
                      tile_start = tile_idx * self.TILE_SIZE
                      out0[total_produced:total_produced + tile_len] = npu_output[
                          tile_start:tile_start + tile_len]

                      tile_abs_start = output_abs_start + total_produced
                      tag_count = max(
                          0, min(int(tile_meta["tag_count"]), MAX_TAGS_PER_TILE))
                      for tag in tile_meta["tags"][:tag_count]:
                          tag_offset = int(tag["offset"])
                          if 0 <= tag_offset < tile_len:
                              self._add_frame_tags(tile_abs_start + tag_offset, tag)

                      total_produced += tile_len

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced

          def _add_frame_tags(self, offset, tag):
              csi = np.empty(CSI_SIZE, dtype=np.complex64)
              csi.real = tag["csi"]["real"] * Q16_15_SCALE
              csi.imag = tag["csi"]["imag"] * Q16_15_SCALE

              values = {
                  "frame_bytes": pmt.from_uint64(int(tag["frame_bytes"])),
                  "encoding": pmt.from_uint64(int(tag["encoding"])),
                  "snr": pmt.from_double(10.0 * np.log10(int(tag["snr_linear"]) / 32.0)),
                  "nominal_frequency": pmt.from_double(int(tag["center_frequency_mhz"]) * 1e6),
                  "frequency_offset": pmt.from_double(
                      int(tag["frequency_offset"]) / (1 << 29) * 20e6 / (2.0 * np.pi)),
                  "beta": pmt.from_double(int(tag["beta"]) / (1 << 29)),
                  "csi": pmt.init_c32vector(52, csi[:52].tolist()),
              }
              for name, value in values.items():
                  self.add_item_tag(
                      0, offset, self.tag_keys[name], value, self.tag_srcid)
    kernel_name: '"MLIR_AIE"'
    nominal_frequency: freq
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
  states: {state: disabled}
- name: epy_block_energy_logger
  id: epy_block
  parameters:
    _source_code: |
      import atexit
      import csv
      from pathlib import Path
      import threading
      import time

      from gnuradio import gr


      class blk(gr.basic_block):
          """Log energy using low-rate polling, without any streaming ports.

          Lifecycle snippets prepare the baseline before streaming, start the sampler
          after native counters are initialized, and finalize after top_block.wait().
          No Python work callback or extra IQ buffer reader is scheduled.

          Attributes:
              csv_path (Path): CSV destination, overwritten at each start.
              interval (float): Requested delay between sensor readings in seconds.
              rapl (Path): RAPL package domain directory.
              supplies (Path): ACPI power supply directory.
              samples (int): Number of complex IQ samples last polled from the native counter.
          """

          def __init__(self, csv_path="original_energy.csv", interval=0.5,
                       rapl_path="/sys/class/powercap/intel-rapl:0",
                       power_supply_path="/sys/class/power_supply"):
              """Initialize the monitor without opening sensors or starting a thread.

              Args:
                  csv_path (str): Destination path for the measurement CSV.
                  interval (float): Sampling delay in seconds, at least 0.05.
                  rapl_path (str): Directory containing energy_uj, name, and
                      max_energy_range_uj for the measured RAPL domain.
                  power_supply_path (str): Directory containing the battery and
                      external power supply sysfs entries.

              Raises:
                  ValueError: If interval is less than 0.05 seconds.
              """
              gr.basic_block.__init__(self, name="Run Energy Logger",
                                     in_sig=None, out_sig=None)
              if interval < 0.05:
                  raise ValueError("Energy sampling interval must be at least 0.05 s")
              self.csv_path = Path(csv_path)
              self.interval = interval
              self.rapl = Path(rapl_path)
              self.supplies = Path(power_supply_path)
              self.samples = 0
              self._counter = lambda: 0
              self._sensor_files = {}
              self._last_flush_ns = 0
              self._done = threading.Event()
              self._thread = None
              self._file = None
              self._error = None
              self._previous = None
              self._energy_j = 0.0

          def _read(self, path):
              """Read a sysfs attribute and remove surrounding whitespace.

              Args:
                  path (Path): Attribute file to read.

              Returns:
                  str: Stripped attribute value.

              Raises:
                  OSError: If the attribute cannot be read.
              """
              stream = self._sensor_files.get(path)
              if stream is None:
                  stream = path.open("r")
                  self._sensor_files[path] = stream
              stream.seek(0)
              return stream.read().strip()

          def _close_sensors(self):
              """Close cached sysfs files after the sampler thread has stopped."""
              for stream in self._sensor_files.values():
                  stream.close()
              self._sensor_files.clear()

          def _battery_reading(self):
              """Read battery measurements only while unplugged and discharging.

              Returns:
                  tuple: External power online flag (bool), battery status (str),
                  discharge power in watts (float), and stored energy in joules
                  (float). The last two values are empty strings when plugged in
                  or when the battery is not discharging.

              Raises:
                  OSError: If a required power supply attribute cannot be read.
                  ValueError: If a numeric attribute cannot be parsed.
              """
              # ACPI sysfs is also the source of sensors' BAT0-acpi power1.
              online = any(int(self._read(path / "online")) != 0
                           for path in self._external)
              status = self._read(self._battery / "status")
              unplugged = not online and status == "Discharging"
              if not unplugged:
                  return online, status, "", ""
              # power_now is in microwatts; energy_now is in micro-watt-hours.
              watts = int(self._read(self._battery / "power_now")) / 1e6
              joules = int(self._read(self._battery / "energy_now")) * 0.0036
              return online, status, watts, joules

          def _sample(self, phase):
              """Take one sensor snapshot, update energy totals, and buffer a CSV row.

              The first reading establishes the monotonic time and counter baseline.
              Later readings derive interval-average package power and cumulative
              energy. Calls must be serialized between startup, the monitor thread,
              and finalization.

              Args:
                  phase (str): Row marker: "start", "sample", or "end".

              Raises:
                  OSError: If a sensor read or CSV write fails.
                  ValueError: If a numeric sensor attribute cannot be parsed.
              """
              counter = int(self._read(self.rapl / "energy_uj"))
              now = time.monotonic_ns()
              self.samples = int(self._counter())
              wall = time.time_ns()
              online, status, system_w, battery_j = self._battery_reading()
              power_w = ""
              if self._previous is None:
                  self._start_ns = now
              else:
                  previous_ns, previous_counter = self._previous
                  delta = counter - previous_counter
                  if delta < 0:
                      # Correct one counter wrap between consecutive readings.
                      delta += self._range_uj
                  self._energy_j += delta / 1e6
                  # Convert microjoules / nanoseconds to joules / second (watts).
                  power_w = delta * 1000.0 / (now - previous_ns)
              self._previous = now, counter
              self._writer.writerow({
                  "phase": phase,
                  "unix_time_ns": wall,
                  "elapsed_s": (now - self._start_ns) / 1e9,
                  "samples_processed": self.samples,
                  "rapl_domain": self._domain,
                  "rapl_energy_uj": counter,
                  "rapl_max_energy_range_uj": self._range_uj,
                  "soc_energy_j": self._energy_j,
                  "soc_power_w": power_w,
                  "ac_online": int(online),
                  "battery_status": status,
                  "system_power_w": system_w,
                  "battery_energy_j": battery_j,
              })
              # Flush boundary rows and at most once every five seconds during the run.
              if phase != "sample" or now - self._last_flush_ns >= 5_000_000_000:
                  self._file.flush()
                  self._last_flush_ns = now

          def _prepare_logging(self):
              """Initialize sensors, CSV output, and a not-yet-started sampler thread.

              Called by begin_logging() before the flowgraph starts. Takes the baseline
              reading synchronously before launching the monitor thread and
              registers an exit-time cleanup fallback.

              Returns:
                  bool: True when initialization succeeds.

              Raises:
                  RuntimeError: If there is not exactly one battery or no external
                      power supply online indicator is available.
                  OSError: If sensor discovery, attribute reads, or CSV setup fails.
                  ValueError: If a numeric sensor attribute cannot be parsed.
              """
              self.csv_path = Path(self.csv_path)
              self.rapl = Path(self.rapl)
              self.supplies = Path(self.supplies)
              self.samples = 0
              self._counter = lambda: 0
              self._last_flush_ns = 0
              self._thread = None
              self._previous = None
              self._energy_j = 0.0
              self._error = None
              self._done.clear()
              self._range_uj = int(self._read(self.rapl / "max_energy_range_uj"))
              self._domain = self._read(self.rapl / "name")
              batteries = [p for p in self.supplies.iterdir()
                           if (p / "type").exists() and self._read(p / "type") == "Battery"]
              if len(batteries) != 1:
                  raise RuntimeError("Energy logger requires exactly one battery")
              self._battery = batteries[0]
              self._external = [p for p in self.supplies.iterdir()
                                if p != self._battery and (p / "online").exists()]
              if not self._external:
                  raise RuntimeError("No external power supply online indicator found")
              self.csv_path.parent.mkdir(parents=True, exist_ok=True)
              self._file = self.csv_path.open("w", newline="")
              self._writer = csv.DictWriter(self._file, fieldnames=[
                  "phase", "unix_time_ns", "elapsed_s", "samples_processed",
                  "rapl_domain", "rapl_energy_uj", "rapl_max_energy_range_uj",
                  "soc_energy_j", "soc_power_w", "ac_online", "battery_status",
                  "system_power_w", "battery_energy_j"])
              self._writer.writeheader()
              try:
                  self._sample("start")
              except Exception:
                  self._file.close()
                  self._file = None
                  raise
              self._thread = threading.Thread(target=self._monitor, daemon=True)
              atexit.register(self.finish_logging)
              return True

          def _monitor(self):
              """Sample periodically until finalization requests a stop.

              Waiting on the event lets finalization wake the thread immediately.
              Sensor or write errors are saved and re-raised by finish_logging(),
              leaving the CSV without an end marker.
              """
              while not self._done.wait(self.interval):
                  try:
                      self._sample("sample")
                  except Exception as error:
                      self._error = error
                      return

          def finish_logging(self):
              """Stop monitoring, take the final reading, and close the CSV.

              Call after top_block.wait() returns. This method is idempotent after
              the CSV closes. The monitor is joined before the final reading to
              prevent concurrent writes. Cleanup closes the CSV even on failure.

              Raises:
                  RuntimeError: If background sampling failed.
                  OSError: If the final sensor read or CSV write fails.
                  ValueError: If a final numeric sensor attribute cannot be parsed.
              """
              # The IQ branch can finish before the decoder. Do not finalize in
              # block.stop(): the flowgraph's after-stop snippet calls this after wait().
              if self._file is None:
                  self._close_sensors()
                  return
              self._done.set()
              if self._thread is not None and self._thread.ident is not None:
                  self._thread.join()
              try:
                  if self._error is not None:
                      raise RuntimeError("Energy sampling failed") from self._error
                  self._sample("end")
              finally:
                  self._file.close()
                  self._file = None
                  self._close_sensors()
                  atexit.unregister(self.finish_logging)

          def begin_logging(self):
              """Take the baseline before top_block.start(), without starting a thread.

              Raises:
                  RuntimeError: If logging is active or sensor discovery fails.
                  OSError: If sensors or the CSV cannot be accessed.
                  ValueError: If a numeric sensor reading is invalid.
              """
              if self._file is not None:
                  raise RuntimeError("Energy logging is already active")
              try:
                  self._prepare_logging()
              except Exception:
                  self.finish_logging()
                  raise

          def start_monitoring(self, sample_counter):
              """Start sampling after the native source has initialized its counters.

              Args:
                  sample_counter (Callable[[], int]): Native IQ sample counter, polled
                      once per sensor snapshot rather than per streaming buffer.

              Raises:
                  RuntimeError: If logging is unprepared or monitoring is already active.
              """
              if self._file is None or self._thread.ident is not None:
                  raise RuntimeError("Prepare logging once before starting monitoring")
              self._counter = sample_counter
              self._thread.start()
    comment: No stream ports; lifecycle snippets control low-rate native-counter polling.
    csv_path: data_dir + "/tmp_out/npu_energy.csv"
    interval: '0.5'
    power_supply_path: '"/sys/class/power_supply"'
    rapl_path: '"/sys/class/powercap/intel-rapl:0"'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [epy_block_0_0, '0', blocks_stream_to_vector_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [mlir_aie_complex64_to_cint16_0, '0', epy_block_0_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
