options:
  parameters:
    description: CPU and NVIDIA GPU energy measurement for the CUDA Wi-Fi receiver.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: GR-WiFi CUDA Energy Experiment
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Capture root on this machine.
    value: '"/home/piloteer/바탕화면/WiFi_Paper_Data/SUB"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/stress_test.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: energy_logger_finish
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.finish_logging()
    comment: Finish after all processing, on EOF or SIGINT/SIGTERM.
    section: main_after_stop
  states: {}
- name: energy_logger_prepare
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.begin_logging()
    section: main_after_init
  states: {}
- name: energy_logger_start
  id: snippet
  parameters:
    code: |
      import time
      progress = [None, time.monotonic()]

      def finish_at_eof():
          # CUDA demodcu is a stream sink that also decodes and emits PDUs.
          # It has no stream output counter or separate decoder block.
          # Allow it to drain after upstream completion; an incomplete final
          # frame can leave the native block waiting indefinitely at EOF.
          if not all(block.detail().done() for block in (
                  self.blocks_interleaved_short_to_complex_0,
                  self.ieee80211_trigger_0_0, self.ieee80211_sync_0_0,
                  self.ieee80211_signal_0_0)):
              return
          counter = self.ieee80211cu_demodcu_0.nitems_read(0)
          now = time.monotonic()
          if counter != progress[0]:
              progress[:] = [counter, now]
          elif now - progress[1] >= 2.0:
              self.stop()

      self.epy_block_energy_logger.start_monitoring(
          lambda: self.blocks_interleaved_short_to_complex_0.nitems_written(0),
          finish_at_eof)
    section: main_after_start
  states: {}
- name: epy_block_energy_logger
  id: epy_block
  parameters:
    _source_code: |
      import atexit
      import csv
      import ctypes
      from pathlib import Path
      import threading
      import time

      from gnuradio import gr


      class blk(gr.basic_block):
          """Poll CPU RAPL and NVIDIA NVML without adding streaming ports.

          CPU energy is measured by RAPL. GPU energy is a trapezoidal estimate
          from board-power readings, including other processes and idle power.
          """

          def __init__(self, csv_path="gr_ieee80211_energy.csv", interval=0.5,
                       rapl_path="/sys/class/powercap/intel-rapl:0", gpu_index=0):
              gr.basic_block.__init__(self, name="Run Energy Logger",
                                     in_sig=None, out_sig=None)
              if interval < 0.05:
                  raise ValueError("Energy sampling interval must be at least 0.05 s")
              self.csv_path = Path(csv_path)
              self.interval = interval
              self.rapl = Path(rapl_path)
              self.gpu_index = gpu_index
              self.samples = 0
              self._counter = lambda: 0
              self._sensor_files = {}
              self._done = threading.Event()
              self._thread = None
              self._file = None
              self._nvml = None

          def _read(self, path):
              stream = self._sensor_files.get(path)
              if stream is None:
                  stream = path.open("r")
                  self._sensor_files[path] = stream
              stream.seek(0)
              return stream.read().strip()

          def _nvml_call(self, name, *args):
              result = getattr(self._nvml, name)(*args)
              if result:
                  message = self._nvml.nvmlErrorString(result).decode()
                  raise RuntimeError(f"{name}: {message}")

          def _open_gpu(self):
              # NVML ships with the NVIDIA driver; no Python package is required.
              library = ctypes.CDLL("libnvidia-ml.so.1")
              signatures = {
                  "nvmlInit_v2": [], "nvmlShutdown": [],
                  "nvmlDeviceGetHandleByIndex_v2": [ctypes.c_uint, ctypes.POINTER(ctypes.c_void_p)],
                  "nvmlDeviceGetPowerUsage": [ctypes.c_void_p, ctypes.POINTER(ctypes.c_uint)],
                  "nvmlDeviceGetName": [ctypes.c_void_p, ctypes.c_void_p, ctypes.c_uint],
                  "nvmlDeviceGetUUID": [ctypes.c_void_p, ctypes.c_void_p, ctypes.c_uint],
              }
              for name, arguments in signatures.items():
                  function = getattr(library, name)
                  function.argtypes = arguments
                  function.restype = ctypes.c_int
              library.nvmlErrorString.argtypes = [ctypes.c_int]
              library.nvmlErrorString.restype = ctypes.c_char_p
              self._nvml = library
              try:
                  self._nvml_call("nvmlInit_v2")
              except Exception:
                  self._nvml = None
                  raise
              self._gpu = ctypes.c_void_p()
              self._nvml_call("nvmlDeviceGetHandleByIndex_v2", self.gpu_index,
                              ctypes.byref(self._gpu))
              name = ctypes.create_string_buffer(96)
              uuid = ctypes.create_string_buffer(96)
              self._nvml_call("nvmlDeviceGetName", self._gpu, name, len(name))
              self._nvml_call("nvmlDeviceGetUUID", self._gpu, uuid, len(uuid))
              self._gpu_name = name.value.decode()
              self._gpu_uuid = uuid.value.decode()

          def _close_sensors(self):
              for stream in self._sensor_files.values():
                  stream.close()
              self._sensor_files.clear()
              if self._nvml is not None:
                  try:
                      self._nvml_call("nvmlShutdown")
                  finally:
                      self._nvml = None

          def _sample(self, phase):
              counter = int(self._read(self.rapl / "energy_uj"))
              now = time.monotonic_ns()
              self.samples = int(self._counter())
              power_mw = ctypes.c_uint()
              self._nvml_call("nvmlDeviceGetPowerUsage", self._gpu, ctypes.byref(power_mw))
              gpu_w = power_mw.value / 1000.0
              cpu_w = ""
              if self._previous is None:
                  self._start_ns = now
              else:
                  previous_ns, previous_counter, previous_gpu_w = self._previous
                  dt = (now - previous_ns) / 1e9
                  delta = counter - previous_counter
                  if delta < 0:
                      delta += self._range_uj
                  self._cpu_j += delta / 1e6
                  cpu_w = delta / 1e6 / dt
                  self._gpu_j += dt * (previous_gpu_w + gpu_w) / 2
              self._previous = now, counter, gpu_w
              self._writer.writerow({
                  "phase": phase, "unix_time_ns": time.time_ns(),
                  "elapsed_s": (now - self._start_ns) / 1e9,
                  "samples_processed": self.samples,
                  "rapl_domain": self._domain, "rapl_energy_uj": counter,
                  "rapl_max_energy_range_uj": self._range_uj,
                  "cpu_energy_j": self._cpu_j, "cpu_power_w": cpu_w,
                  "gpu_index": self.gpu_index, "gpu_name": self._gpu_name,
                  "gpu_uuid": self._gpu_uuid, "gpu_power_w": gpu_w,
                  "gpu_energy_j": self._gpu_j,
              })
              if phase != "sample" or now - self._last_flush_ns >= 5_000_000_000:
                  self._file.flush()
                  self._last_flush_ns = now

          def begin_logging(self):
              """Initialize sensors and take a baseline before top_block.start()."""
              if self._file is not None:
                  raise RuntimeError("Energy logging is already active")
              self.samples = 0
              self._counter = lambda: 0
              self._previous = None
              self._cpu_j = self._gpu_j = 0.0
              self._last_flush_ns = 0
              self._error = None
              self._thread = None
              self._done.clear()
              try:
                  self._range_uj = int(self._read(self.rapl / "max_energy_range_uj"))
                  self._domain = self._read(self.rapl / "name")
                  self._open_gpu()
                  self.csv_path = Path(self.csv_path)
                  self.csv_path.parent.mkdir(parents=True, exist_ok=True)
                  self._file = self.csv_path.open("w", newline="")
                  self._writer = csv.DictWriter(self._file, fieldnames=[
                      "phase", "unix_time_ns", "elapsed_s", "samples_processed",
                      "rapl_domain", "rapl_energy_uj", "rapl_max_energy_range_uj",
                      "cpu_energy_j", "cpu_power_w", "gpu_index", "gpu_name",
                      "gpu_uuid", "gpu_power_w", "gpu_energy_j",
                  ])
                  self._writer.writeheader()
                  self._sample("start")
                  self._thread = threading.Thread(target=self._monitor, daemon=True)
              except Exception:
                  if self._file is not None:
                      self._file.close()
                      self._file = None
                  self._close_sensors()
                  raise
              atexit.register(self.finish_logging)

          def start_monitoring(self, sample_counter, on_poll=None):
              """Poll the native complex-IQ counter after streaming starts."""
              if self._file is None or self._thread.ident is not None:
                  raise RuntimeError("Prepare logging once before starting monitoring")
              self._counter = sample_counter
              self._on_poll = on_poll
              self._thread.start()

          def _monitor(self):
              while not self._done.wait(self.interval):
                  try:
                      self._sample("sample")
                      if self._on_poll is not None:
                          self._on_poll()
                  except Exception as error:
                      self._error = error
                      return

          def finish_logging(self):
              """Finalize after top_block.wait(), including downstream decoding time."""
              if self._file is None:
                  return
              self._done.set()
              if self._thread is not None and self._thread.ident is not None:
                  self._thread.join()
              try:
                  if self._error is not None:
                      raise RuntimeError("Energy sampling failed") from self._error
                  self._sample("end")
              finally:
                  self._file.close()
                  self._file = None
                  atexit.unregister(self.finish_logging)
                  self._close_sensors()
    comment: No stream ports; RAPL CPU energy and NVML GPU power at 0.5 s intervals.
    csv_path: data_dir + "/tmp_out/gr_ieee80211cu_energy.csv"
    gpu_index: '0'
    interval: '0.5'
    rapl_path: '"/sys/class/powercap/intel-rapl:0"'
  states: {}
- name: ieee80211_signal_0_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: ieee80211cu_demodcu_0
  id: ieee80211cu_demodcu
  parameters:
    ifdebug: 'False'
    mugid: '2'
    mupos: '0'
  states: {}
- name: import_local_cuda
  id: import
  parameters:
    imports: |
      from ctypes import CDLL, RTLD_GLOBAL
      # Load the patched user-local runtime before importing ieee80211cu bindings.
      CDLL("/home/piloteer/git/gr-ieee80211cu/build/lib/libgnuradio-ieee80211cu.so", mode=RTLD_GLOBAL)
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {}
- name: presisocu_0
  id: presisocu
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [ieee80211_signal_0_0, '0', ieee80211cu_demodcu_0, '0']
- [ieee80211_sync_0_0, '0', ieee80211_signal_0_0, '0']
- [ieee80211_trigger_0_0, '0', ieee80211_sync_0_0, '0']
- [ieee80211cu_demodcu_0, out, network_socket_pdu_0, pdus]
- [presisocu_0, '0', ieee80211_trigger_0_0, '0']
- [presisocu_0, '1', ieee80211_sync_0_0, '1']
- [virtual_source_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0, '0', ieee80211_signal_0_0, '1']
- [virtual_source_0, '0', ieee80211_sync_0_0, '2']
- [virtual_source_0, '0', presisocu_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
