options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Native-block 20 MHz Wi-Fi fixture; 2000 frames (~10 s) by default, with sample-exact SigMF annotations.
    generate_options: no_gui
    id: wifi_tx_sigmf
    output_language: python
    run_options: run
    title: Wi-Fi latency SigMF generator
  states: {}

blocks:
- name: body_samples
  id: variable
  parameters:
    value: (frame_count - 1) * frame_spacing + frame_samples
  states: {}
- name: first_sample
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: frame_count
  id: parameter
  parameters:
    comment: '2000 frames at 5 ms spacing: approximately 10 seconds of replay.'
    label: Frame count
    type: intx
    value: '2000'
  states: {}
- name: frame_samples
  id: variable
  parameters:
    comment: BPSK 1/2, MAC+FCS=28 bytes, five preamble/SIGNAL symbols, rolloff=2.
    value: 80 * (5 + (16 + 8 * (pdu_length + 28) + 6 + 23) // 24) + 1
  states: {}
- name: frame_spacing
  id: variable
  parameters:
    comment: 100000 samples at 20 MSamples/s = 5 ms between frames (200 frames/s).
    value: '100000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2412000000'
  states: {}
- name: noise_seed
  id: variable
  parameters:
    comment: Native Noise Source uses seed 0 for system time; use a positive seed.
    value: '1'
  states: {}
- name: noise_std
  id: parameter
  parameters:
    comment: Gaussian standard deviation per I/Q; increase to exercise the MLP path.
    label: Noise standard deviation
    type: eng_float
    value: '0.003'
  states: {}
- name: output_base
  id: parameter
  parameters:
    comment: SigMF basename; use a separate name to preserve the original capture.
    label: Output basename
    type: str
    value: '"wifi_latency"'
  states: {}
- name: payloads
  id: variable
  parameters:
    value: '[(''WIFI-LATENCY:%08d:'' % i).ljust(pdu_length, ''x'') for i in range(frame_count)]'
  states: {}
- name: pdu_length
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: tail_samples
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: total_samples
  id: variable
  parameters:
    value: first_sample + body_samples + tail_samples
  states: {}
- name: tx_scale
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: await_capture
  id: snippet
  parameters:
    code: |-
      import time
      deadline = time.monotonic() + max(60.0, 10.0 * self.total_samples / self.samp_rate)
      try:
          while (min(self.iq_file.nitems_read(0), self.output_tags.nitems_read(0)) < self.total_samples
                 or len(self.phy_tags.current_tags()) < self.frame_count):
              if time.monotonic() > deadline:
                  raise RuntimeError("Timed out waiting for native capture blocks")
              time.sleep(0.01)
      finally:
          self.stop()
          self.wait()
    section: main_after_start
  states: {}
- name: background_noise
  id: analog_noise_source_x
  parameters:
    amp: noise_std * 2**0.5
    noise_type: analog.GR_GAUSSIAN
    seed: noise_seed
    type: complex
  states: {}
- name: capture_length
  id: blocks_head
  parameters:
    num_items: total_samples
    type: complex
  states: {}
- name: epy_block_metadata
  id: epy_block
  parameters:
    _source_code: |
      import hashlib
      import json
      from pathlib import Path
      import sys
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Metadata only: no streaming ports or Python work callback."""

          def __init__(self):
              gr.basic_block.__init__(self, name="SigMF metadata", in_sig=None, out_sig=None)

          def prepare(self, g):
              if not (sys.byteorder == "little" and g.frame_count > 0 and
                      32 <= g.pdu_length <= 1500 and g.first_sample >= 0 and
                      g.tail_samples >= 0 and g.frame_spacing >= g.frame_samples and
                      g.samp_rate > 0 and g.noise_seed > 0 and g.noise_std >= 0 and g.tx_scale > 0):
                  raise ValueError("Invalid capture parameters or non-little-endian host")
              Path(g.output_base + ".sigmf-meta").unlink(missing_ok=True)
              g.phy_tags.set_save_all(True)
              g.output_tags.set_save_all(True)

          def write(self, g):
              g.iq_file.close()  # Native File Sink flushes before hashing.
              path = Path(g.output_base + ".sigmf-data")
              bursts, placed = g.phy_tags.current_tags(), g.output_tags.current_tags()
              if path.stat().st_size != g.total_samples * 8 or len(bursts) != g.frame_count or len(placed) != g.frame_count:
                  raise RuntimeError("Incomplete capture or frame tag count mismatch")
              annotations = []
              for i, (burst, tag) in enumerate(zip(bursts, placed)):
                  start, length = int(tag.offset), int(pmt.to_long(burst.value))
                  if length != g.frame_samples or burst.offset != i * length or start != g.first_sample + i * g.frame_spacing:
                      raise RuntimeError("Native PHY length or scheduled offset mismatch")
                  annotations.append({"core:sample_start": start, "core:sample_count": length,
                      "core:label": "wifi-frame-%08d" % i, "core:comment": json.dumps({
                          "frame_id": i, "payload_ascii": g.payloads[i], "payload_bytes": g.pdu_length,
                          "psdu_bytes": g.pdu_length + 28, "encoding": "BPSK 1/2",
                          "mac_sequence_number": i % 4096, "start_seconds": start / g.samp_rate,
                          "end_seconds": (start + length) / g.samp_rate})})
              with path.open("rb") as data:
                  checksum = hashlib.file_digest(data, "sha512").hexdigest()
              metadata = {"global": {"core:datatype": "cf32_le", "core:sample_rate": g.samp_rate,
                  "core:num_channels": 1, "core:version": "1.2.0", "core:sha512": checksum,
                  "core:recorder": "wifi_tx_sigmf.grc (native GNU Radio blocks)",
                  "core:description": "BPSK 1/2; tx_scale=%g; native Gaussian noise std=%g per I/Q, seed=%d; no CFO or multipath. Annotations include PHY windowing tail." %
                      (g.tx_scale, g.noise_std, g.noise_seed)},
                  "captures": [{"core:sample_start": 0, "core:frequency": g.freq}], "annotations": annotations}
              Path(g.output_base + ".sigmf-meta").write_text(json.dumps(metadata, indent=2) + "\n")
              print("Wrote %d frames, %d complex samples to %s" % (g.frame_count, g.total_samples, path))
  states: {}
- name: finish_metadata
  id: snippet
  parameters:
    code: self.epy_block_metadata.write(self)
    section: main_after_stop
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: iq_file
  id: blocks_file_sink
  parameters:
    file: output_base + '.sigmf-data'
    type: complex
  states: {}
- name: leading_zeros
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0,)
  states: {}
- name: output_tags
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: packet_len
    name: Scheduled frame positions
    type: complex
  states: {}
- name: packet_pad
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.01'
    minoutbuf: 2 * frame_spacing
    pad_front: '0'
    pad_tail: frame_spacing - frame_samples
  states: {}
- name: payload_bytes
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: list(''.join(payloads).encode('ascii'))
  states: {}
- name: payload_packets
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pdu_length
    type: byte
  states: {}
- name: payload_pdus
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: phy_tags
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: packet_len
    name: PHY burst lengths
    type: complex
  states: {}
- name: prepare_metadata
  id: snippet
  parameters:
    code: self.epy_block_metadata.prepare(self)
    section: main_after_init
  states: {}
- name: timeline
  id: blocks_stream_mux
  parameters:
    lengths: (first_sample, body_samples, tail_samples)
    num_inputs: '3'
    type: complex
  states: {}
- name: trailing_zeros
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0,)
  states: {}
- name: tx_gain
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_scale
    type: complex
  states: {}
- name: unused_rx_input
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (0,)
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: samp_rate
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(0)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [add_noise, '0', capture_length, '0']
- [background_noise, '0', add_noise, '1']
- [capture_length, '0', iq_file, '0']
- [capture_length, '0', output_tags, '0']
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [leading_zeros, '0', timeline, '0']
- [packet_pad, '0', timeline, '1']
- [payload_bytes, '0', payload_packets, '0']
- [payload_packets, '0', payload_pdus, '0']
- [payload_pdus, pdus, ieee802_11_mac_0, app in]
- [timeline, '0', tx_gain, '0']
- [trailing_zeros, '0', timeline, '2']
- [tx_gain, '0', add_noise, '0']
- [unused_rx_input, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', packet_pad, '0']
- [wifi_phy_hier_0, '0', phy_tags, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
