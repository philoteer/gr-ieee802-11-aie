options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: file_path
  id: variable
  parameters:
    value: '"data/raw_capture/206.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: data/tmp_out/replaced.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    VECTOR_SIZE: '4096'
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      #
      # Copyright 2026 gr-mlir_aie author.
      #
      # SPDX-License-Identifier: GPL-3.0-or-later
      #


      import numpy as np
      from gnuradio import gr
      import pmt

      import aie.iron as iron
      from aie.utils import DefaultNPURuntime, NPUKernel
      import os
      import tempfile


      INPUT_DTYPE = np.int32
      OUTPUT_DTYPE = np.int8
      METADATA_DTYPE = np.int32

      MAX_TAGS_PER_TILE = 16
      N_TILES = 4
      CSI_SIZE = 64
      Q16_15_SCALE = 1.0 / (1 << 15)

      # These aligned dtypes reproduce tag_metadata and tile_metadata from the C++
      # block, including the uint64 fields and the CSI complex pairs.
      CSI_DTYPE = np.dtype([
          ("real", np.int32),
          ("imag", np.int32),
      ], align=True)
      TAG_METADATA_DTYPE = np.dtype([
          ("offset", np.int32),
          ("frame_start", np.uint32),
          ("frame_bytes", np.uint64),
          ("encoding", np.uint64),
          ("snr_linear", np.uint64),
          ("center_frequency_mhz", np.uint32),
          ("frequency_offset", np.int32),
          ("beta", np.int32),
          ("csi", CSI_DTYPE, (CSI_SIZE,)),
      ], align=True)
      TILE_METADATA_DTYPE = np.dtype([
          ("output_length", np.int32),
          ("tag_count", np.int32),
          ("tags", TAG_METADATA_DTYPE, (MAX_TAGS_PER_TILE,)),
      ], align=True)
      METADATA_WORDS = N_TILES * TILE_METADATA_DTYPE.itemsize // np.dtype(
          METADATA_DTYPE).itemsize


      class mlir_aie_python_80211_phy(gr.basic_block):
          """Run the MLIR-AIE 802.11 PHY and recreate frame equalizer tags."""

          def __init__(self,
                       path_xclbin="kernel/build/final.xclbin",
                       path_insts_bin="kernel/build/insts.bin",
                       kernel_name="MLIR_AIE",
                       VECTOR_SIZE=4096,
                       nominal_frequency=2.417e9):
              gr.basic_block.__init__(
                  self,
                  name="mlir_aie_python_80211_phy",
                  in_sig=[INPUT_DTYPE],
                  out_sig=[OUTPUT_DTYPE],
              )

              center_frequency_mhz = round(nominal_frequency / 1e6)
              instructions = np.fromfile(path_insts_bin, dtype=np.uint32).copy()
              for marker, value in ((0x13579BDF, center_frequency_mhz), (0x2468ACE0, round(20.0 / center_frequency_mhz * (1 << 30)))):
                  matches = np.flatnonzero(instructions == marker)
                  if len(matches) != 1:
                      raise RuntimeError("center-frequency RTP marker is missing or ambiguous")
                  instructions[matches[0]] = np.uint32(value)
              self.rtp_dir = tempfile.TemporaryDirectory()
              patched_insts = os.path.join(self.rtp_dir.name, "insts.bin")
              instructions.tofile(patched_insts)

              npu_kernel = NPUKernel(
                  path_xclbin,
                  patched_insts,
                  kernel_name=kernel_name,
              )
              self.kernel_handle = DefaultNPURuntime.load(npu_kernel)
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=OUTPUT_DTYPE)
              self.out_meta_buf = iron.zeros(METADATA_WORDS, dtype=METADATA_DTYPE)
              self.VECTOR_SIZE = VECTOR_SIZE
              self.TILE_SIZE = VECTOR_SIZE // N_TILES
              self.nominal_frequency = nominal_frequency

              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.tag_srcid = pmt.intern("frame_equalizer")
              self.tag_keys = {
                  "frame_bytes": pmt.intern("frame bytes"),
                  "encoding": pmt.intern("encoding"),
                  "snr": pmt.intern("snr"),
                  "nominal_frequency": pmt.intern("nominal frequency"),
                  "frequency_offset": pmt.intern("frequency offset"),
                  "beta": pmt.intern("beta"),
                  "csi": pmt.intern("csi"),
              }

          def forecast(self, noutput_items, ninputs):
              return [noutput_items] * ninputs

          def set_nominal_frequency(self, nominal_frequency):
              self.nominal_frequency = nominal_frequency

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]
              n_chunks = min(len(in0), len(out0)) // self.VECTOR_SIZE

              if n_chunks == 0:
                  return 0

              output_abs_start = self.nitems_written(0)
              total_produced = 0

              for chunk_idx in range(n_chunks):
                  input_start = chunk_idx * self.VECTOR_SIZE
                  input_end = input_start + self.VECTOR_SIZE
                  current_in_tensor = iron.tensor(
                      in0[input_start:input_end], dtype=INPUT_DTYPE)

                  DefaultNPURuntime.run(
                      self.kernel_handle,
                      [current_in_tensor, self.out_buf, self.out_meta_buf],
                  )

                  npu_output = self.out_buf.numpy()
                  metadata = self.out_meta_buf.numpy().view(
                      TILE_METADATA_DTYPE).reshape(N_TILES)

                  for tile_idx, tile_meta in enumerate(metadata):
                      tile_len = max(
                          0, min(int(tile_meta["output_length"]), self.TILE_SIZE))
                      tile_start = tile_idx * self.TILE_SIZE
                      out0[total_produced:total_produced + tile_len] = npu_output[
                          tile_start:tile_start + tile_len]

                      tile_abs_start = output_abs_start + total_produced
                      tag_count = max(
                          0, min(int(tile_meta["tag_count"]), MAX_TAGS_PER_TILE))
                      for tag in tile_meta["tags"][:tag_count]:
                          tag_offset = int(tag["offset"])
                          if 0 <= tag_offset < tile_len:
                              self._add_frame_tags(tile_abs_start + tag_offset, tag)

                      total_produced += tile_len

              self.consume_each(n_chunks * self.VECTOR_SIZE)
              return total_produced

          def _add_frame_tags(self, offset, tag):
              csi = np.empty(CSI_SIZE, dtype=np.complex64)
              csi.real = tag["csi"]["real"] * Q16_15_SCALE
              csi.imag = tag["csi"]["imag"] * Q16_15_SCALE

              values = {
                  "frame_bytes": pmt.from_uint64(int(tag["frame_bytes"])),
                  "encoding": pmt.from_uint64(int(tag["encoding"])),
                  "snr": pmt.from_double(10.0 * np.log10(int(tag["snr_linear"]) / 32.0)),
                  "nominal_frequency": pmt.from_double(int(tag["center_frequency_mhz"]) * 1e6),
                  "frequency_offset": pmt.from_double(
                      int(tag["frequency_offset"]) / (1 << 29) * 20e6 / (2.0 * np.pi)),
                  "beta": pmt.from_double(int(tag["beta"]) / (1 << 29)),
                  "csi": pmt.init_c32vector(52, csi[:52].tolist()),
              }
              for name, value in values.items():
                  self.add_item_tag(
                      0, offset, self.tag_keys[name], value, self.tag_srcid)
    kernel_name: '"MLIR_AIE"'
    nominal_frequency: freq
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
  states: {state: disabled}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: '"kernel/build/insts.bin"'
    path_xclbin: '"kernel/build/final.xclbin"'
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [epy_block_0_0, '0', blocks_stream_to_vector_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [mlir_aie_complex64_to_cint16_0, '0', epy_block_0_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
