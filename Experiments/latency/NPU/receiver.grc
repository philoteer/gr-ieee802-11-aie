options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency.sigmf"'
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency_mlp_active.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.412e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Pace IQ before timestamping; release at most 1024 samples per call.
    limit: items
    maximum: '1024'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_latency
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt


      class blk(gr.basic_block):
          """Print host-side PHY chunk-completion latency for annotated frames."""

          def __init__(self):
              gr.basic_block.__init__(self, name="PHY latency", in_sig=None, out_sig=None)
              self.starts = {}
              self.count = 0
              self.total_ms = 0.0
              self.message_port_register_in(pmt.intern("latency"))
              self.set_msg_handler(pmt.intern("latency"), self.handle_latency)

          def handle_latency(self, message):
              if not pmt.is_pair(message):
                  return
              key, value = pmt.car(message), pmt.cdr(message)
              if not pmt.is_symbol(key) or not pmt.is_dict(value):
                  return
              event = pmt.symbol_to_string(key)
              if event not in ("frame_start", "frame_end"):
                  return
              frame_id = pmt.dict_ref(value, pmt.intern("frame_id"), pmt.PMT_NIL)
              times = pmt.dict_ref(value, pmt.intern("timestamps_ns"), pmt.PMT_NIL)
              if not pmt.is_symbol(frame_id) or not pmt.is_dict(times):
                  return
              start = pmt.dict_ref(times, pmt.intern("phy_start"), pmt.PMT_NIL)
              end = pmt.dict_ref(times, pmt.intern("phy_end"), pmt.PMT_NIL)
              if not pmt.is_uint64(start) or not pmt.is_uint64(end):
                  return
              frame_id = pmt.symbol_to_string(frame_id)
              start, end = pmt.to_uint64(start), pmt.to_uint64(end)
              if event == "frame_start":
                  self.starts[frame_id] = start
                  return
              first = self.starts.pop(frame_id, None)
              if first is None or end < start or end < first:
                  return
              elapsed_ms = (end - first) / 1e6
              tail_ms = (end - start) / 1e6
              self.count += 1
              self.total_ms += elapsed_ms
              print(f"[PHY latency estimate] {frame_id}: "
                    f"start-to-completion={elapsed_ms:.4f} ms, "
                    f"end-to-completion={tail_ms:.4f} ms, "
                    f"mean={self.total_ms / self.count:.4f} ms (n={self.count})",
                    flush=True)
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'True'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_latency_tag_updater_0
  id: mlir_aie_latency_tag_updater
  parameters:
    name: phy_start
    type: int
    vlen: '1'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: /home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/xclbin_default/CNN_BY_CHANNEL/insts.bin
    path_xclbin: /home/piloteer/xdna_phy/gr-ieee802-11-aie/Experiments/xclbin_default/CNN_BY_CHANNEL/final.xclbin
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [blocks_throttle_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_latency_tag_updater_0, '0']
- [mlir_aie_latency_tag_updater_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, latency, epy_block_latency, latency]
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
