options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy/gr-ieee802-11.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/gr-ieee802-11/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2412000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Pace IQ before timestamping, as in the NPU latency experiment.
    limit: items
    maximum: '1024'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_latency
  id: epy_block
  parameters:
    _source_code: |
      import json
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Match input boundary tags to CRC-valid decoded MAC payloads.

          IQ passes through unchanged. Input timestamps are retained outside the
          stream so synchronization and equalization may discard latency tags.
          Completion is measured at decoded-PDU handler entry, including message
          delivery delay. All timestamps use the host monotonic clock.

          Attributes:
              by_payload (dict): Payload bytes mapped to frame label and MAC sequence.
              frames (dict): Frame labels mapped to start, end, and done timestamps
                  in nanoseconds, plus a reported flag once a latency is printed.
              lock (threading.Lock): Protects frame state and counters across callbacks.
              count (int): Number of frames with a printed latency measurement.
              total_ms (float): Sum of reported start-to-decoded latencies.
              unmatched (int): Decoded packets without a matching payload/sequence pair.
              duplicates (int): Additional decoded packets for an already seen frame.
          """

          def __init__(self, metadata_file="../wifi_latency.sigmf-meta"):
              """Load expected frame identities and register the decoded-PDU input.

              Args:
                  metadata_file (str): SigMF metadata path. Wi-Fi annotations must
                      contain unique labels and ASCII payloads, with payload_ascii
                      and mac_sequence_number fields in their JSON core:comment.

              Raises:
                  OSError: If the metadata file cannot be read.
                  ValueError: If JSON is invalid, no latency frames are present, or
                      frame labels or payloads are ambiguous.
                  KeyError: If a required annotation identity field is missing.
              """
              gr.sync_block.__init__(self, name="PHY latency (payload match)",
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              with open(metadata_file) as stream:
                  metadata = json.load(stream)
              self.by_payload = {}
              self.frames = {}
              for annotation in metadata.get("annotations", []):
                  label = annotation.get("core:label", "")
                  if not label.startswith("wifi-frame-"):
                      continue
                  info = json.loads(annotation["core:comment"])
                  payload = info["payload_ascii"].encode("ascii")
                  if payload in self.by_payload or label in self.frames:
                      raise ValueError("Latency matching requires unique frame IDs and payloads")
                  self.by_payload[payload] = (label, info["mac_sequence_number"])
                  self.frames[label] = {}
              if not self.frames:
                  raise ValueError("No annotated Wi-Fi latency frames found")
              self.lock = threading.Lock()
              self.count = 0
              self.total_ms = 0.0
              self.unmatched = 0
              self.duplicates = 0
              self.message_port_register_in(pmt.intern("decoded"))
              self.set_msg_handler(pmt.intern("decoded"), self.handle_decoded)

          def work(self, input_items, output_items):
              """Collect input boundary timestamps and forward the IQ buffer.

              Args:
                  input_items (list): GNU Radio input buffers; port 0 is complex64 IQ.
                  output_items (list): Writable complex64 output buffer on port 0.

              Returns:
                  int: Number of samples consumed and produced.
              """
              count = len(input_items[0])
              # Read tags inline, before releasing these samples to the receiver.
              # Keep timestamps out-of-band; sync/equalizer blocks may drop tags.
              with self.lock:
                  for tag in self.get_tags_in_window(0, 0, count):
                      if not any(pmt.eq(tag.key, pmt.intern(k)) for k in ("frame_start", "frame_end")):
                          continue
                      if not pmt.is_dict(tag.value):
                          continue
                      label = pmt.dict_ref(tag.value, pmt.intern("frame_id"), pmt.PMT_NIL)
                      stamp = pmt.dict_ref(tag.value, pmt.intern("timestamp_ns"), pmt.PMT_NIL)
                      if not pmt.is_symbol(label) or not pmt.is_uint64(stamp):
                          continue
                      label = pmt.symbol_to_string(label)
                      if label in self.frames:
                          event = "start" if pmt.eq(tag.key, pmt.intern("frame_start")) else "end"
                          self.frames[label].setdefault(event, pmt.to_uint64(stamp))
                          self.report(label)
              output_items[0][:count] = input_items[0][:count]
              return count

          def handle_decoded(self, message):
              """Match a CRC-valid decoded MAC PDU and retain its completion time.

              The decoder removes the FCS. Matching assumes a 24-byte MAC header:
              bytes 22:24 hold sequence control and bytes 24 onward are the payload.
              Exact payload and sequence matching avoids shifting identities after
              a lost or reordered packet. The first completion wins for duplicates.

              Args:
                  message (pmt.pmt_t): Decoder PDU containing metadata and MAC bytes
                      as a blob or u8vector. Malformed message envelopes are ignored.
              """
              # Timestamp at handler entry, before matching/printing/locking.
              completed = time.monotonic_ns()
              if not pmt.is_pair(message):
                  return
              data = pmt.cdr(message)
              if not (pmt.is_blob(data) or pmt.is_u8vector(data)):
                  return
              mac = bytes(pmt.to_python(data))
              match = self.by_payload.get(mac[24:]) if len(mac) >= 24 else None
              with self.lock:
                  if match is None or int.from_bytes(mac[22:24], "little") >> 4 != match[1]:
                      self.unmatched += 1
                      return
                  label = match[0]
                  frame = self.frames[label]
                  if "done" in frame:
                      self.duplicates += 1
                      return
                  frame["done"] = completed
                  self.report(label)

          def report(self, label):
              """Print one latency sample when both boundaries and completion exist.

              The caller must hold self.lock. Completion may be observed before the
              annotation's final windowing-tail tag; reporting waits for all three
              timestamps without changing the original completion time. The tail
              latency can be negative if decoding precedes the end-tag timestamp.

              Args:
                  label (str): Known frame label identifying the retained timestamps.
              """
              # Called with lock held. Output delivery can precede the annotation's
              # final windowing-tail tag, so retain completion until both tags exist.
              frame = self.frames[label]
              if frame.get("reported") or not all(k in frame for k in ("start", "end", "done")):
                  return
              elapsed_ms = (frame["done"] - frame["start"]) / 1e6
              tail_ms = (frame["done"] - frame["end"]) / 1e6
              frame["reported"] = True
              self.count += 1
              self.total_ms += elapsed_ms
              print(f"[PHY latency estimate] {label}: "
                    f"start-to-decoded={elapsed_ms:.4f} ms, "
                    f"end-to-decoded={tail_ms:.4f} ms, "
                    f"mean={self.total_ms / self.count:.4f} ms (n={self.count})",
                    flush=True)

          def finish(self):
              """Print matching counters and missing frame IDs after workers finish.

              Call after top_block.wait() so input-tag collection and decoded-PDU
              handling have finished before the final summary is calculated.
              """
              with self.lock:
                  missing = [label for label, frame in self.frames.items() if not frame.get("reported")]
                  print(f"[PHY latency summary] matched={self.count}/{len(self.frames)}, "
                        f"unmatched-output={self.unmatched}, duplicate-output={self.duplicates}", flush=True)
                  if missing:
                      print("[PHY latency summary] missing: " + ", ".join(missing), flush=True)
    comment: Input tags are matched to decoded payload IDs without PHY tag propagation.
    metadata_file: file_path+"-meta"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: latency_finish
  id: snippet
  parameters:
    code: self.epy_block_latency.finish()
    comment: Summarize matched and missing frames after all workers finish.
    section: main_after_stop
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [epy_block_latency, '0', virtual_sink_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_decode_mac_0, out, epy_block_latency, decoded]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', epy_block_latency, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
