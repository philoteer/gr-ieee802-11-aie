options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: wifi_rx
    output_language: python
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: '0'
  states: {}
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy/gr-ieee802-11.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/gr-ieee802-11/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency.sigmf"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '2412000000.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '320'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '48'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '16'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: window_size  + 16
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: window_size
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Pace IQ before timestamping, as in the NPU latency experiment.
    limit: items
    maximum: '1024'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_latency
  id: epy_block
  parameters:
    _source_code: |
      import json
      import threading
      import time

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Match native input and equalizer timestamps without processing IQ.

          Boundary messages preserve the source's timestamp_ns. Completion uses
          phy_equalized_ns from the final equalized output symbol. Decoding only identifies the frame.
          Python delivery, matching, and printing delays are excluded from the
          reported interval. All timestamps use the host monotonic clock.

          Attributes:
              by_payload (dict): Payload bytes mapped to frame label and MAC sequence.
              frames (dict): Frame labels mapped to native start, end, and done
                  timestamps in nanoseconds, plus delivery time and a reported flag.
              lock (threading.Lock): Protects frame state and counters across callbacks.
              count (int): Number of frames with a printed latency measurement.
              total_ms (float): Sum of reported start-to-equalized latencies.
              unmatched (int): Decoded packets without a matching payload/sequence pair.
              duplicates (int): Additional decoded packets for an already seen frame.
          """

          def __init__(self, metadata_file="../wifi_latency.sigmf-meta"):
              """Load expected frame identities and register the decoded-PDU input.

              Args:
                  metadata_file (str): SigMF metadata path. Wi-Fi annotations must
                      contain unique labels and ASCII payloads, with payload_ascii
                      and mac_sequence_number fields in their JSON core:comment.

              Raises:
                  OSError: If the metadata file cannot be read.
                  ValueError: If JSON is invalid, no latency frames are present, or
                      frame labels or payloads are ambiguous.
                  KeyError: If a required annotation identity field is missing.
              """
              gr.basic_block.__init__(self, name="PHY latency (native timestamps)",
                                      in_sig=None, out_sig=None)
              with open(metadata_file) as stream:
                  metadata = json.load(stream)
              self.by_payload = {}
              self.frames = {}
              for annotation in metadata.get("annotations", []):
                  label = annotation.get("core:label", "")
                  if not label.startswith("wifi-frame-"):
                      continue
                  info = json.loads(annotation["core:comment"])
                  payload = info["payload_ascii"].encode("ascii")
                  if payload in self.by_payload or label in self.frames:
                      raise ValueError("Latency matching requires unique frame IDs and payloads")
                  self.by_payload[payload] = (label, info["mac_sequence_number"])
                  self.frames[label] = {}
              if not self.frames:
                  raise ValueError("No annotated Wi-Fi latency frames found")
              self.lock = threading.Lock()
              self.count = 0
              self.total_ms = 0.0
              self.unmatched = 0
              self.duplicates = 0
              self.message_port_register_in(pmt.intern("decoded"))
              self.set_msg_handler(pmt.intern("decoded"), self.handle_decoded)
              self.message_port_register_in(pmt.intern("boundaries"))
              self.set_msg_handler(pmt.intern("boundaries"), self.handle_boundary)

          def handle_boundary(self, message):
              """Retain a native ingress timestamp received from the tag-monitor tap.

              Args:
                  message (pmt.pmt_t): Pair of frame_start/frame_end and an annotation
                      dictionary containing frame_id and timestamp_ns. Malformed or
                      unknown events are ignored. Arrival time is never substituted.
              """
              if not pmt.is_pair(message):
                  return
              key, value = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(value):
                  return
              if pmt.eq(key, pmt.intern("frame_start")):
                  event = "start"
              elif pmt.eq(key, pmt.intern("frame_end")):
                  event = "end"
              else:
                  return
              label = pmt.dict_ref(value, pmt.intern("frame_id"), pmt.PMT_NIL)
              stamp = pmt.dict_ref(value, pmt.intern("timestamp_ns"), pmt.PMT_NIL)
              if not pmt.is_symbol(label) or not pmt.is_uint64(stamp):
                  return
              label = pmt.symbol_to_string(label)
              with self.lock:
                  if label in self.frames:
                      self.frames[label].setdefault(event, pmt.to_uint64(stamp))
                      self.report(label)

          def handle_decoded(self, message):
              """Match a CRC-valid MAC PDU using its native completion timestamp.

              The decoder removes the FCS. Matching assumes a 24-byte MAC header:
              bytes 22:24 hold sequence control and bytes 24 onward are the payload.
              Exact payload and sequence matching avoids shifting identities after
              a lost or reordered packet. The first completion wins for duplicates.

              Args:
                  message (pmt.pmt_t): Decoder PDU carrying unchanged phy_equalized_ns metadata and
                      MAC bytes as a blob or u8vector. Malformed envelopes are ignored.

              Raises:
                  RuntimeError: If native completion metadata is absent, indicating
                      an incompatible decoder (usually the system library).
              """
              # Diagnostic only: this Python arrival time is NOT the measurement endpoint.
              observed = time.monotonic_ns()
              if not pmt.is_pair(message):
                  return
              data = pmt.cdr(message)
              if not (pmt.is_blob(data) or pmt.is_u8vector(data)):
                  return
              metadata = pmt.car(message)
              completed = pmt.dict_ref(metadata, pmt.intern("phy_equalized_ns"), pmt.PMT_NIL) if pmt.is_dict(metadata) else pmt.PMT_NIL
              if not pmt.is_uint64(completed):
                  raise RuntimeError("PDU lacks phy_equalized_ns; source ./local-env.sh")
              completed = pmt.to_uint64(completed)
              mac = bytes(pmt.to_python(data))
              match = self.by_payload.get(mac[24:]) if len(mac) >= 24 else None
              with self.lock:
                  if match is None or int.from_bytes(mac[22:24], "little") >> 4 != match[1]:
                      self.unmatched += 1
                      return
                  label = match[0]
                  frame = self.frames[label]
                  if "done" in frame:
                      self.duplicates += 1
                      return
                  frame["done"] = completed
                  frame["observed"] = observed
                  self.report(label)

          def report(self, label):
              """Print one latency sample when both boundaries and completion exist.

              The caller must hold self.lock. Completion may be observed before the
              annotation's final windowing-tail tag; reporting waits for all three
              timestamps without changing the original completion time. The tail
              latency can be negative if equalization precedes the end-tag timestamp.

              Args:
                  label (str): Known frame label identifying the retained timestamps.
              """
              # Called with lock held. Output delivery can precede the annotation's
              # final windowing-tail tag, so retain completion until both tags exist.
              frame = self.frames[label]
              if frame.get("reported") or not all(k in frame for k in ("start", "end", "done")):
                  return
              elapsed_ms = (frame["done"] - frame["start"]) / 1e6
              tail_ms = (frame["done"] - frame["end"]) / 1e6
              frame["reported"] = True
              self.count += 1
              self.total_ms += elapsed_ms
              print(f"[PHY latency estimate] {label}: "
                    f"start-to-equalized={elapsed_ms:.4f} ms, "
                    f"end-to-equalized={tail_ms:.4f} ms, "
                    f"mean={self.total_ms / self.count:.4f} ms (n={self.count})",
                    flush=True)

          def finish(self):
              """Print matching counters and missing frame IDs after workers finish.

              Call after top_block.wait() so input-tag collection and decoded-PDU
              handling have finished before the final summary is calculated.
              """
              with self.lock:
                  missing = [label for label, frame in self.frames.items() if not frame.get("reported")]
                  print(f"[PHY latency summary] matched={self.count}/{len(self.frames)}, "
                        f"unmatched-output={self.unmatched}, duplicate-output={self.duplicates}", flush=True)
                  if missing:
                      print("[PHY latency summary] missing: " + ", ".join(missing), flush=True)
    comment: Message-only reporter; all measurement timestamps are native.
    metadata_file: file_path+"-meta"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(64)
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_frame_equalizer_0
  id: ieee802_11_frame_equalizer
  parameters:
    algo: ieee802_11.Equalizer(chan_est)
    bw: samp_rate
    debug: 'False'
    freq: freq
    log: 'False'
  states: {}
- name: ieee802_11_latency_tag_monitor_0
  id: ieee802_11_latency_tag_monitor
  parameters:
    comment: Native side tap; preserves ingress timestamps without Python IQ processing.
  states: {}
- name: ieee802_11_sync_long_0
  id: ieee802_11_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length
  states: {}
- name: ieee802_11_sync_short_0
  id: ieee802_11_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: '2'
    threshold: '0.56'
  states: {}
- name: latency_finish
  id: snippet
  parameters:
    code: self.epy_block_latency.finish()
    comment: Summarize matched and missing frames after all workers finish.
    section: main_after_stop
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', ieee802_11_sync_long_0, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', ieee802_11_sync_short_0, '0']
- [blocks_divide_xx_0, '0', ieee802_11_sync_short_0, '2']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_moving_average_xx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_1, '0', ieee802_11_sync_short_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [fft_vxx_0, '0', ieee802_11_frame_equalizer_0, '0']
- [ieee802_11_decode_mac_0, out, epy_block_latency, decoded]
- [ieee802_11_frame_equalizer_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_latency_tag_monitor_0, events, epy_block_latency, boundaries]
- [ieee802_11_sync_long_0, '0', blocks_stream_to_vector_0, '0']
- [ieee802_11_sync_short_0, '0', blocks_delay_0, '0']
- [ieee802_11_sync_short_0, '0', ieee802_11_sync_long_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', ieee802_11_latency_tag_monitor_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
