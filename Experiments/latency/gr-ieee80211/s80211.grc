options:
  parameters:
    description: GR-WiFi latency with native timestamps and message-only reporting.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: GR-WiFi Latency Experiment
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy/gr-ieee80211.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/gr-ieee80211/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency.sigmf"'
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/206.sigmf"
  states: {state: disabled}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {state: disabled}
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: data_dir + "/raw_capture/wifi_iq_hackrf.bin"
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '255.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Pace IQ before timestamping, matching the other latency experiments.
    limit: items
    maximum: '1024'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: ieee80211_latency_tag_monitor_0
  id: ieee80211_latency_tag_monitor
  parameters:
    comment: Native side tap forwarding original ingress timestamps.
  states: {}
- name: latency_finish
  id: snippet
  parameters:
    code: self.epy_block_latency.finish()
    comment: Summarize after all processing has finished.
    section: main_after_stop
  states: {}
- name: epy_block_latency
  id: epy_block
  parameters:
    _source_code: |
      import json
      import threading
      import time
      import zlib

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Match native ingress and GR-WiFi equalizer timestamps without IQ work.

          Input boundaries retain the injector's timestamp_ns. Completion uses
          phy_equalized_ns stamped on the final demodulated output symbol.
          Payload decoding only identifies the frame and carries that time unchanged.
          Decoding, Python delivery, matching, and printing are outside the interval.

          Attributes:
              by_payload (dict): Payload bytes mapped to frame label and sequence.
              frames (dict): Frame labels mapped to native start/end/done timestamps
                  in nanoseconds, diagnostic observed time, and a reported flag.
              lock (threading.Lock): Protects frame state and counters.
              count (int): Number of reported frames.
              total_ms (float): Sum of reported start-to-equalized latencies.
              unmatched (int): Packets without a matching payload and sequence.
              duplicates (int): Additional decoded packets for an already seen ID.
              malformed (int): Data packets with invalid envelope length or FCS.
          """

          def __init__(self, metadata_file="../wifi_latency.sigmf-meta"):
              """Load expected identities and register message inputs.

              Args:
                  metadata_file (str): SigMF metadata containing wifi-frame-...
                      annotations with payload_ascii and mac_sequence_number in
                      each annotation's JSON core:comment.

              Raises:
                  OSError: If metadata cannot be read.
                  ValueError: If JSON is invalid, no frames exist, or labels or
                      payloads are ambiguous.
                  KeyError: If required identity fields are missing.
              """
              gr.basic_block.__init__(self, name="GR-WiFi PHY latency",
                                      in_sig=None, out_sig=None)
              with open(metadata_file) as stream:
                  metadata = json.load(stream)
              self.by_payload = {}
              self.frames = {}
              for annotation in metadata.get("annotations", []):
                  label = annotation.get("core:label", "")
                  if not label.startswith("wifi-frame-"):
                      continue
                  info = json.loads(annotation["core:comment"])
                  payload = info["payload_ascii"].encode("ascii")
                  if payload in self.by_payload or label in self.frames:
                      raise ValueError("Latency matching requires unique frame IDs and payloads")
                  self.by_payload[payload] = (label, info["mac_sequence_number"])
                  self.frames[label] = {}
              if not self.frames:
                  raise ValueError("No annotated Wi-Fi latency frames found")
              self.lock = threading.Lock()
              self.count = 0
              self.total_ms = 0.0
              self.unmatched = 0
              self.duplicates = 0
              self.malformed = 0
              self.message_port_register_in(pmt.intern("boundaries"))
              self.set_msg_handler(pmt.intern("boundaries"), self.handle_boundary)
              self.message_port_register_in(pmt.intern("decoded"))
              self.set_msg_handler(pmt.intern("decoded"), self.handle_decoded)

          def handle_boundary(self, message):
              """Retain an original native timestamp regardless of delivery time.

              Args:
                  message (pmt.pmt_t): Pair of frame_start/frame_end and a metadata
                      dictionary with frame_id and timestamp_ns. Invalid or unknown
                      events are ignored.
              """
              if not pmt.is_pair(message):
                  return
              key, value = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(value):
                  return
              if pmt.eq(key, pmt.intern("frame_start")):
                  event = "start"
              elif pmt.eq(key, pmt.intern("frame_end")):
                  event = "end"
              else:
                  return
              label = pmt.dict_ref(value, pmt.intern("frame_id"), pmt.PMT_NIL)
              stamp = pmt.dict_ref(value, pmt.intern("timestamp_ns"), pmt.PMT_NIL)
              if not pmt.is_symbol(label) or not pmt.is_uint64(stamp):
                  return
              label = pmt.symbol_to_string(label)
              with self.lock:
                  if label in self.frames:
                      self.frames[label].setdefault(event, pmt.to_uint64(stamp))
                      self.report(label)

          def handle_decoded(self, message):
              """Unwrap a CRC-valid GR-WiFi packet and match its native completion.

              GR-WiFi emits format (1 byte), PSDU length (2 bytes, little-endian),
              PSDU including FCS, and MCS (1 byte). This experiment uses 24-byte
              MAC headers. Channel-report PDUs are ignored. The first completion
              for a matching payload/sequence wins, even if boundaries arrive later.

              Args:
                  message (pmt.pmt_t): Decoder PDU carrying phy_equalized_ns metadata
                      and a blob/u8vector containing the GR-WiFi envelope.

              Raises:
                  RuntimeError: If a valid data packet lacks a native timestamp,
                      usually because the system decoder was loaded by mistake.
              """
              observed = time.monotonic_ns()  # Diagnostic only, never the endpoint.
              if not pmt.is_pair(message):
                  return
              data = pmt.cdr(message)
              if not (pmt.is_blob(data) or pmt.is_u8vector(data)):
                  return
              packet = bytes(pmt.to_python(data))
              if not packet or packet[0] not in (0, 1, 2):
                  return  # Not a legacy/HT/VHT decoded data packet.
              length = int.from_bytes(packet[1:3], "little")
              if length < 28 or len(packet) != length + 4 or zlib.crc32(packet[3:3 + length]) != 0x2144df1c:
                  with self.lock:
                      self.malformed += 1
                  return
              metadata = pmt.car(message)
              completed = pmt.dict_ref(metadata, pmt.intern("phy_equalized_ns"), pmt.PMT_NIL) if pmt.is_dict(metadata) else pmt.PMT_NIL
              if not pmt.is_uint64(completed):
                  raise RuntimeError("PDU lacks phy_equalized_ns; source ./local-env.sh")
              completed = pmt.to_uint64(completed)
              mac = packet[3:3 + length - 4]  # Remove envelope and four-byte FCS.
              match = self.by_payload.get(mac[24:])
              with self.lock:
                  if match is None or int.from_bytes(mac[22:24], "little") >> 4 != match[1]:
                      self.unmatched += 1
                      return
                  label = match[0]
                  frame = self.frames[label]
                  if "done" in frame:
                      self.duplicates += 1
                      return
                  frame["done"] = completed
                  frame["observed"] = observed
                  self.report(label)

          def report(self, label):
              """Print a sample once both boundaries and completion are available.

              The caller must hold self.lock. Either message input may arrive
              first; stored native timestamps are never replaced by arrival times.

              Args:
                  label (str): Known annotated frame label.
              """
              frame = self.frames[label]
              if frame.get("reported") or not all(k in frame for k in ("start", "end", "done")):
                  return
              elapsed_ms = (frame["done"] - frame["start"]) / 1e6
              tail_ms = (frame["done"] - frame["end"]) / 1e6
              frame["reported"] = True
              self.count += 1
              self.total_ms += elapsed_ms
              print(f"[PHY latency estimate] {label}: "
                    f"start-to-equalized={elapsed_ms:.4f} ms, "
                    f"end-to-equalized={tail_ms:.4f} ms, "
                    f"mean={self.total_ms / self.count:.4f} ms (n={self.count})",
                    flush=True)

          def finish(self):
              """Print matching counters and missing IDs after top_block.wait()."""
              with self.lock:
                  missing = [label for label, frame in self.frames.items() if not frame.get("reported")]
                  print(f"[PHY latency summary] matched={self.count}/{len(self.frames)}, "
                        f"unmatched-output={self.unmatched}, duplicate-output={self.duplicates}, "
                        f"malformed-output={self.malformed}", flush=True)
                  if missing:
                      print("[PHY latency summary] missing: " + ", ".join(missing), flush=True)
    comment: Message-only reporter using native input and completion timestamps.
    metadata_file: file_path+"-meta"
  states: {}
- name: energy_logger_finish
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.finish_logging()
    comment: Finish after all processing, on EOF or SIGINT/SIGTERM.
    section: main_after_stop
  states: {state: disabled}
- name: energy_logger_prepare
  id: snippet
  parameters:
    code: self.epy_block_energy_logger.begin_logging()
    section: main_after_init
  states: {state: disabled}
- name: energy_logger_start
  id: snippet
  parameters:
    code: 'self.epy_block_energy_logger.start_monitoring(lambda: self.mlir_aie_sigmf_tag_injector_0.nitems_written(0))'
    section: main_after_start
  states: {state: disabled}
- name: epy_block_energy_logger
  id: epy_block
  parameters:
    _source_code: |
      import atexit
      import csv
      from pathlib import Path
      import threading
      import time

      from gnuradio import gr


      class blk(gr.basic_block):
          """Log energy using low-rate polling, without any streaming ports.

          Lifecycle snippets prepare the baseline before streaming, start the sampler
          after native counters are initialized, and finalize after top_block.wait().
          No Python work callback or extra IQ buffer reader is scheduled.

          Attributes:
              csv_path (Path): CSV destination, overwritten at each start.
              interval (float): Requested delay between sensor readings in seconds.
              rapl (Path): RAPL package domain directory.
              supplies (Path): ACPI power supply directory.
              samples (int): Number of complex IQ samples last polled from the native counter.
          """

          def __init__(self, csv_path="original_energy.csv", interval=0.5,
                       rapl_path="/sys/class/powercap/intel-rapl:0",
                       power_supply_path="/sys/class/power_supply"):
              """Initialize the monitor without opening sensors or starting a thread.

              Args:
                  csv_path (str): Destination path for the measurement CSV.
                  interval (float): Sampling delay in seconds, at least 0.05.
                  rapl_path (str): Directory containing energy_uj, name, and
                      max_energy_range_uj for the measured RAPL domain.
                  power_supply_path (str): Directory containing the battery and
                      external power supply sysfs entries.

              Raises:
                  ValueError: If interval is less than 0.05 seconds.
              """
              gr.basic_block.__init__(self, name="Run Energy Logger",
                                     in_sig=None, out_sig=None)
              if interval < 0.05:
                  raise ValueError("Energy sampling interval must be at least 0.05 s")
              self.csv_path = Path(csv_path)
              self.interval = interval
              self.rapl = Path(rapl_path)
              self.supplies = Path(power_supply_path)
              self.samples = 0
              self._counter = lambda: 0
              self._sensor_files = {}
              self._last_flush_ns = 0
              self._done = threading.Event()
              self._thread = None
              self._file = None
              self._error = None
              self._previous = None
              self._energy_j = 0.0

          def _read(self, path):
              """Read a sysfs attribute and remove surrounding whitespace.

              Args:
                  path (Path): Attribute file to read.

              Returns:
                  str: Stripped attribute value.

              Raises:
                  OSError: If the attribute cannot be read.
              """
              stream = self._sensor_files.get(path)
              if stream is None:
                  stream = path.open("r")
                  self._sensor_files[path] = stream
              stream.seek(0)
              return stream.read().strip()

          def _close_sensors(self):
              """Close cached sysfs files after the sampler thread has stopped."""
              for stream in self._sensor_files.values():
                  stream.close()
              self._sensor_files.clear()

          def _battery_reading(self):
              """Read battery measurements only while unplugged and discharging.

              Returns:
                  tuple: External power online flag (bool), battery status (str),
                  discharge power in watts (float), and stored energy in joules
                  (float). The last two values are empty strings when plugged in
                  or when the battery is not discharging.

              Raises:
                  OSError: If a required power supply attribute cannot be read.
                  ValueError: If a numeric attribute cannot be parsed.
              """
              # ACPI sysfs is also the source of sensors' BAT0-acpi power1.
              online = any(int(self._read(path / "online")) != 0
                           for path in self._external)
              status = self._read(self._battery / "status")
              unplugged = not online and status == "Discharging"
              if not unplugged:
                  return online, status, "", ""
              # power_now is in microwatts; energy_now is in micro-watt-hours.
              watts = int(self._read(self._battery / "power_now")) / 1e6
              joules = int(self._read(self._battery / "energy_now")) * 0.0036
              return online, status, watts, joules

          def _sample(self, phase):
              """Take one sensor snapshot, update energy totals, and buffer a CSV row.

              The first reading establishes the monotonic time and counter baseline.
              Later readings derive interval-average package power and cumulative
              energy. Calls must be serialized between startup, the monitor thread,
              and finalization.

              Args:
                  phase (str): Row marker: "start", "sample", or "end".

              Raises:
                  OSError: If a sensor read or CSV write fails.
                  ValueError: If a numeric sensor attribute cannot be parsed.
              """
              counter = int(self._read(self.rapl / "energy_uj"))
              now = time.monotonic_ns()
              self.samples = int(self._counter())
              wall = time.time_ns()
              online, status, system_w, battery_j = self._battery_reading()
              power_w = ""
              if self._previous is None:
                  self._start_ns = now
              else:
                  previous_ns, previous_counter = self._previous
                  delta = counter - previous_counter
                  if delta < 0:
                      # Correct one counter wrap between consecutive readings.
                      delta += self._range_uj
                  self._energy_j += delta / 1e6
                  # Convert microjoules / nanoseconds to joules / second (watts).
                  power_w = delta * 1000.0 / (now - previous_ns)
              self._previous = now, counter
              self._writer.writerow({
                  "phase": phase,
                  "unix_time_ns": wall,
                  "elapsed_s": (now - self._start_ns) / 1e9,
                  "samples_processed": self.samples,
                  "rapl_domain": self._domain,
                  "rapl_energy_uj": counter,
                  "rapl_max_energy_range_uj": self._range_uj,
                  "soc_energy_j": self._energy_j,
                  "soc_power_w": power_w,
                  "ac_online": int(online),
                  "battery_status": status,
                  "system_power_w": system_w,
                  "battery_energy_j": battery_j,
              })
              # Flush boundary rows and at most once every five seconds during the run.
              if phase != "sample" or now - self._last_flush_ns >= 5_000_000_000:
                  self._file.flush()
                  self._last_flush_ns = now

          def _prepare_logging(self):
              """Initialize sensors, CSV output, and a not-yet-started sampler thread.

              Called by begin_logging() before the flowgraph starts. Takes the baseline
              reading synchronously before launching the monitor thread and
              registers an exit-time cleanup fallback.

              Returns:
                  bool: True when initialization succeeds.

              Raises:
                  RuntimeError: If there is not exactly one battery or no external
                      power supply online indicator is available.
                  OSError: If sensor discovery, attribute reads, or CSV setup fails.
                  ValueError: If a numeric sensor attribute cannot be parsed.
              """
              self.csv_path = Path(self.csv_path)
              self.rapl = Path(self.rapl)
              self.supplies = Path(self.supplies)
              self.samples = 0
              self._counter = lambda: 0
              self._last_flush_ns = 0
              self._thread = None
              self._previous = None
              self._energy_j = 0.0
              self._error = None
              self._done.clear()
              self._range_uj = int(self._read(self.rapl / "max_energy_range_uj"))
              self._domain = self._read(self.rapl / "name")
              batteries = [p for p in self.supplies.iterdir()
                           if (p / "type").exists() and self._read(p / "type") == "Battery"]
              if len(batteries) != 1:
                  raise RuntimeError("Energy logger requires exactly one battery")
              self._battery = batteries[0]
              self._external = [p for p in self.supplies.iterdir()
                                if p != self._battery and (p / "online").exists()]
              if not self._external:
                  raise RuntimeError("No external power supply online indicator found")
              self.csv_path.parent.mkdir(parents=True, exist_ok=True)
              self._file = self.csv_path.open("w", newline="")
              self._writer = csv.DictWriter(self._file, fieldnames=[
                  "phase", "unix_time_ns", "elapsed_s", "samples_processed",
                  "rapl_domain", "rapl_energy_uj", "rapl_max_energy_range_uj",
                  "soc_energy_j", "soc_power_w", "ac_online", "battery_status",
                  "system_power_w", "battery_energy_j"])
              self._writer.writeheader()
              try:
                  self._sample("start")
              except Exception:
                  self._file.close()
                  self._file = None
                  raise
              self._thread = threading.Thread(target=self._monitor, daemon=True)
              atexit.register(self.finish_logging)
              return True

          def _monitor(self):
              """Sample periodically until finalization requests a stop.

              Waiting on the event lets finalization wake the thread immediately.
              Sensor or write errors are saved and re-raised by finish_logging(),
              leaving the CSV without an end marker.
              """
              while not self._done.wait(self.interval):
                  try:
                      self._sample("sample")
                  except Exception as error:
                      self._error = error
                      return

          def finish_logging(self):
              """Stop monitoring, take the final reading, and close the CSV.

              Call after top_block.wait() returns. This method is idempotent after
              the CSV closes. The monitor is joined before the final reading to
              prevent concurrent writes. Cleanup closes the CSV even on failure.

              Raises:
                  RuntimeError: If background sampling failed.
                  OSError: If the final sensor read or CSV write fails.
                  ValueError: If a final numeric sensor attribute cannot be parsed.
              """
              # The IQ branch can finish before the decoder. Do not finalize in
              # block.stop(): the flowgraph's after-stop snippet calls this after wait().
              if self._file is None:
                  self._close_sensors()
                  return
              self._done.set()
              if self._thread is not None and self._thread.ident is not None:
                  self._thread.join()
              try:
                  if self._error is not None:
                      raise RuntimeError("Energy sampling failed") from self._error
                  self._sample("end")
              finally:
                  self._file.close()
                  self._file = None
                  self._close_sensors()
                  atexit.unregister(self.finish_logging)

          def begin_logging(self):
              """Take the baseline before top_block.start(), without starting a thread.

              Raises:
                  RuntimeError: If logging is active or sensor discovery fails.
                  OSError: If sensors or the CSV cannot be accessed.
                  ValueError: If a numeric sensor reading is invalid.
              """
              if self._file is not None:
                  raise RuntimeError("Energy logging is already active")
              try:
                  self._prepare_logging()
              except Exception:
                  self.finish_logging()
                  raise

          def start_monitoring(self, sample_counter):
              """Start sampling after the native source has initialized its counters.

              Args:
                  sample_counter (Callable[[], int]): Native IQ sample counter, polled
                      once per sensor snapshot rather than per streaming buffer.

              Raises:
                  RuntimeError: If logging is unprepared or monitoring is already active.
              """
              if self._file is None or self._thread.ident is not None:
                  raise RuntimeError("Prepare logging once before starting monitoring")
              self._counter = sample_counter
              self._thread.start()
    comment: No stream ports; lifecycle snippets control low-rate native-counter polling.
    csv_path: data_dir + "/tmp_out/gr_ieee80211_energy.csv"
    interval: '0.5'
    power_supply_path: '"/sys/class/power_supply"'
    rapl_path: '"/sys/class/powercap/intel-rapl:0"'
  states: {state: disabled}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'False'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {state: disabled}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [ieee80211_decode_0, out, network_socket_pdu_0_0, pdus]
- [ieee80211_decode_0, out, epy_block_latency, decoded]
- [ieee80211_latency_tag_monitor_0, events, epy_block_latency, boundaries]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', ieee80211_latency_tag_monitor_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [virtual_source_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0, '0', ieee80211_signal_0, '1']
- [virtual_source_0, '0', ieee80211_sync_0, '2']
- [virtual_source_0, '0', presiso_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
