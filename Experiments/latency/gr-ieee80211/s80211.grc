options:
  parameters:
    description: GR-WiFi latency with native timestamps and message-only reporting.
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_options: run
    title: GR-WiFi Latency Experiment
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    comment: Dataset paths are relative to the generated script in Experiments/energy/gr-ieee80211.
    value: str(__import__("pathlib").Path(globals().get("__file__", "Experiments/energy/gr-ieee80211/wifi_rx.py")).resolve().parents[3] / "AI-model-CNN-Channel-est" / "data")
  states: {}
- name: file_path
  id: variable
  parameters:
    value: '"../wifi_latency.sigmf"'
  states: {}
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path+"-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle2
  parameters:
    comment: Pace IQ before timestamping, matching the other latency experiments.
    limit: items
    maximum: '1024'
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_latency
  id: epy_block
  parameters:
    _source_code: |
      import json
      import threading
      import time
      import zlib

      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """Match native ingress and GR-WiFi equalizer timestamps without IQ work.

          Input boundaries retain the injector's timestamp_ns. Completion uses
          phy_equalized_ns stamped on the final demodulated output symbol.
          Payload decoding only identifies the frame and carries that time unchanged.
          Decoding, Python delivery, matching, and printing are outside the interval.

          Attributes:
              by_payload (dict): Payload bytes mapped to frame label and sequence.
              frames (dict): Frame labels mapped to native start/end/done timestamps
                  in nanoseconds, diagnostic observed time, and a reported flag.
              lock (threading.Lock): Protects frame state and counters.
              count (int): Number of reported frames.
              total_ms (float): Sum of reported start-to-equalized latencies.
              unmatched (int): Packets without a matching payload and sequence.
              duplicates (int): Additional decoded packets for an already seen ID.
              malformed (int): Data packets with invalid envelope length or FCS.
          """

          def __init__(self, metadata_file="../wifi_latency.sigmf-meta"):
              """Load expected identities and register message inputs.

              Args:
                  metadata_file (str): SigMF metadata containing wifi-frame-...
                      annotations with payload_ascii and mac_sequence_number in
                      each annotation's JSON core:comment.

              Raises:
                  OSError: If metadata cannot be read.
                  ValueError: If JSON is invalid, no frames exist, or labels or
                      payloads are ambiguous.
                  KeyError: If required identity fields are missing.
              """
              gr.basic_block.__init__(self, name="GR-WiFi PHY latency",
                                      in_sig=None, out_sig=None)
              with open(metadata_file) as stream:
                  metadata = json.load(stream)
              self.by_payload = {}
              self.frames = {}
              for annotation in metadata.get("annotations", []):
                  label = annotation.get("core:label", "")
                  if not label.startswith("wifi-frame-"):
                      continue
                  info = json.loads(annotation["core:comment"])
                  payload = info["payload_ascii"].encode("ascii")
                  if payload in self.by_payload or label in self.frames:
                      raise ValueError("Latency matching requires unique frame IDs and payloads")
                  self.by_payload[payload] = (label, info["mac_sequence_number"])
                  self.frames[label] = {}
              if not self.frames:
                  raise ValueError("No annotated Wi-Fi latency frames found")
              self.lock = threading.Lock()
              self.count = 0
              self.total_ms = 0.0
              self.unmatched = 0
              self.duplicates = 0
              self.malformed = 0
              self.message_port_register_in(pmt.intern("boundaries"))
              self.set_msg_handler(pmt.intern("boundaries"), self.handle_boundary)
              self.message_port_register_in(pmt.intern("decoded"))
              self.set_msg_handler(pmt.intern("decoded"), self.handle_decoded)

          def handle_boundary(self, message):
              """Retain an original native timestamp regardless of delivery time.

              Args:
                  message (pmt.pmt_t): Pair of frame_start/frame_end and a metadata
                      dictionary with frame_id and timestamp_ns. Invalid or unknown
                      events are ignored.
              """
              if not pmt.is_pair(message):
                  return
              key, value = pmt.car(message), pmt.cdr(message)
              if not pmt.is_dict(value):
                  return
              if pmt.eq(key, pmt.intern("frame_start")):
                  event = "start"
              elif pmt.eq(key, pmt.intern("frame_end")):
                  event = "end"
              else:
                  return
              label = pmt.dict_ref(value, pmt.intern("frame_id"), pmt.PMT_NIL)
              stamp = pmt.dict_ref(value, pmt.intern("timestamp_ns"), pmt.PMT_NIL)
              if not pmt.is_symbol(label) or not pmt.is_uint64(stamp):
                  return
              label = pmt.symbol_to_string(label)
              with self.lock:
                  if label in self.frames:
                      self.frames[label].setdefault(event, pmt.to_uint64(stamp))
                      self.report(label)

          def handle_decoded(self, message):
              """Unwrap a CRC-valid GR-WiFi packet and match its native completion.

              GR-WiFi emits format (1 byte), PSDU length (2 bytes, little-endian),
              PSDU including FCS, and MCS (1 byte). This experiment uses 24-byte
              MAC headers. Channel-report PDUs are ignored. The first completion
              for a matching payload/sequence wins, even if boundaries arrive later.

              Args:
                  message (pmt.pmt_t): Decoder PDU carrying phy_equalized_ns metadata
                      and a blob/u8vector containing the GR-WiFi envelope.

              Raises:
                  RuntimeError: If a valid data packet lacks a native timestamp,
                      usually because the system decoder was loaded by mistake.
              """
              observed = time.monotonic_ns()  # Diagnostic only, never the endpoint.
              if not pmt.is_pair(message):
                  return
              data = pmt.cdr(message)
              if not (pmt.is_blob(data) or pmt.is_u8vector(data)):
                  return
              packet = bytes(pmt.to_python(data))
              if not packet or packet[0] not in (0, 1, 2):
                  return  # Not a legacy/HT/VHT decoded data packet.
              length = int.from_bytes(packet[1:3], "little")
              if length < 28 or len(packet) != length + 4 or zlib.crc32(packet[3:3 + length]) != 0x2144df1c:
                  with self.lock:
                      self.malformed += 1
                  return
              metadata = pmt.car(message)
              completed = pmt.dict_ref(metadata, pmt.intern("phy_equalized_ns"), pmt.PMT_NIL) if pmt.is_dict(metadata) else pmt.PMT_NIL
              if not pmt.is_uint64(completed):
                  raise RuntimeError("PDU lacks phy_equalized_ns; source ./local-env.sh")
              completed = pmt.to_uint64(completed)
              mac = packet[3:3 + length - 4]  # Remove envelope and four-byte FCS.
              match = self.by_payload.get(mac[24:])
              with self.lock:
                  if match is None or int.from_bytes(mac[22:24], "little") >> 4 != match[1]:
                      self.unmatched += 1
                      return
                  label = match[0]
                  frame = self.frames[label]
                  if "done" in frame:
                      self.duplicates += 1
                      return
                  frame["done"] = completed
                  frame["observed"] = observed
                  self.report(label)

          def report(self, label):
              """Print a sample once both boundaries and completion are available.

              The caller must hold self.lock. Either message input may arrive
              first; stored native timestamps are never replaced by arrival times.

              Args:
                  label (str): Known annotated frame label.
              """
              frame = self.frames[label]
              if frame.get("reported") or not all(k in frame for k in ("start", "end", "done")):
                  return
              elapsed_ms = (frame["done"] - frame["start"]) / 1e6
              tail_ms = (frame["done"] - frame["end"]) / 1e6
              frame["reported"] = True
              self.count += 1
              self.total_ms += elapsed_ms
              print(f"[PHY latency estimate] {label}: "
                    f"start-to-equalized={elapsed_ms:.4f} ms, "
                    f"end-to-equalized={tail_ms:.4f} ms, "
                    f"mean={self.total_ms / self.count:.4f} ms (n={self.count})",
                    flush=True)

          def finish(self):
              """Print matching counters and missing IDs after top_block.wait()."""
              with self.lock:
                  missing = [label for label, frame in self.frames.items() if not frame.get("reported")]
                  print(f"[PHY latency summary] matched={self.count}/{len(self.frames)}, "
                        f"unmatched-output={self.unmatched}, duplicate-output={self.duplicates}, "
                        f"malformed-output={self.malformed}", flush=True)
                  if missing:
                      print("[PHY latency summary] missing: " + ", ".join(missing), flush=True)
    comment: Message-only reporter using native input and completion timestamps.
    metadata_file: file_path+"-meta"
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'False'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_latency_tag_monitor_0
  id: ieee80211_latency_tag_monitor
  parameters:
    comment: Native side tap forwarding original ingress timestamps.
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: latency_finish
  id: snippet
  parameters:
    code: self.epy_block_latency.finish()
    comment: Summarize after all processing has finished.
    section: main_after_stop
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path+"-meta"
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [ieee80211_decode_0, out, epy_block_latency, decoded]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_latency_tag_monitor_0, events, epy_block_latency, boundaries]
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', ieee80211_latency_tag_monitor_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', virtual_sink_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [virtual_source_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0, '0', ieee80211_signal_0, '1']
- [virtual_source_0, '0', ieee80211_sync_0, '2']
- [virtual_source_0, '0', presiso_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
