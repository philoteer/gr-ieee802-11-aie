options:
  parameters:
    generate_options: qt_gui
    id: wifirx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq_100
  id: variable
  parameters:
    value: 5500e6
  states: {}
- name: freq_112
  id: variable
  parameters:
    value: 5560e6
  states: {}
- name: freq_132
  id: variable
  parameters:
    value: 5660e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/piloteer/xdna_phy/gr-ieee-802-11-aie/stage43_v2/data/raw_capture/stress_test.sigmf-data
    repeat: 'False'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/piloteer/xdna_phy/gr-ieee-802-11-aie/stage43_v2/data/raw_capture/wifi_iq_hackrf.bin
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '255.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'False'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '65535'
    port: '9527'
    type: UDP_CLIENT
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '4000'
    srate: samp_rate
    type: complex
    update_time: '0.01'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: 20e6
    center_freq0: freq_112
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', virtual_sink_0_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [ieee80211_decode_0, out, network_socket_pdu_0_0, pdus]
- [ieee80211_demod_0, '0', ieee80211_decode_0, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_signal_0, '1']
- [uhd_usrp_source_0, '0', ieee80211_sync_0, '2']
- [uhd_usrp_source_0, '0', presiso_0, '0']
- [virtual_source_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0, '0', ieee80211_signal_0, '1']
- [virtual_source_0, '0', ieee80211_sync_0, '2']
- [virtual_source_0, '0', presiso_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
