options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Verify one SigMF fixture through both CPU receivers and the baseline LS NPU
    generate_options: no_gui
    id: wifi_rx_compat
    output_language: python
    run_options: run
    title: Wi-Fi receiver compatibility check
  states: {}

blocks:
- name: capture_meta
  id: variable
  parameters:
    value: __import__('json').loads(__import__('pathlib').Path(capture_base + '.sigmf-meta').read_text())
  states: {}
- name: freq
  id: variable
  parameters:
    value: capture_meta['captures'][0]['core:frequency']
  states: {}
- name: llr_count
  id: variable
  parameters:
    comment: BPSK 1/2 soft bits; native mux appends lookahead for finite-file decoding.
    value: sum(((16 + 8 * __import__('json').loads(a['core:comment'])['psdu_bytes'] + 6 + 23) // 24) * 48 for a in capture_meta['annotations'])
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: capture_base + ".sigmf-data"
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {}
- name: capture_base
  id: parameter
  parameters:
    label: Capture basename
    type: str
    value: '"wifi_latency"'
  states: {}
- name: check_payloads
  id: snippet
  parameters:
    code: |
      import hashlib
      import json
      from pathlib import Path
      import zlib
      frames, errors = {}, []
      for name, store in self.receivers.items():
          frames[name] = []
          for i in range(store.num_messages()):
              try:
                  mac = bytes(pmt.to_python(pmt.cdr(store.get_message(i))))
                  if name == 'gr-ieee80211':
                      length = int.from_bytes(mac[1:3], 'little')
                      if len(mac) != length + 4 or zlib.crc32(mac[3:3 + length]) != 0x2144df1c:
                          raise ValueError('Invalid GR-WiFi envelope/FCS')
                      mac = mac[3:3 + length - 4]
                  expected = self.expected[i]
                  if mac[24:] != expected['payload_ascii'].encode('ascii') or int.from_bytes(mac[22:24], 'little') >> 4 != expected['mac_sequence_number']:
                      raise ValueError('Payload or MAC sequence mismatch')
                  frames[name].append(expected['frame_id'])
              except Exception as error:
                  errors.append('%s frame %d: %s' % (name, i, error))
          if len(frames[name]) != len(self.expected):
              errors.append('%s: %d/%d matching frames' % (name, len(frames[name]), len(self.expected)))
      report = {'sample_rate': 20000000, 'frequency': self.freq, 'expected_frames': len(self.expected),
          'decoded_frame_ids': frames, 'peak_iq_component': self.peak, 'errors': errors, 'passed': not errors,
          'capture_sha512': self.capture_meta['global']['core:sha512'],
          'npu_configuration': 'base LS, 16384 samples/batch, 16 tiles, 2 slots',
          'npu_xclbin_sha256': hashlib.sha256((Path(self.kernel_dir) / 'final.xclbin').read_bytes()).hexdigest(),
          'npu_insts_sha256': hashlib.sha256((Path(self.kernel_dir) / 'insts.bin').read_bytes()).hexdigest()}
      Path('compat_report.json').write_text(json.dumps(report, indent=2) + '\n')
      if errors:
          raise RuntimeError('; '.join(errors))
      for name in frames:
          print('PASS %s: %d/%d CRC-checked payloads' % (name, len(frames[name]), len(self.expected)))
    section: main_after_stop
  states: {}
- name: finish_check
  id: snippet
  parameters:
    code: |
      import time
      deadline = time.monotonic() + 60
      try:
          while min(b.num_messages() for b in self.receivers.values()) < len(self.expected):
              if time.monotonic() > deadline:
                  break
              time.sleep(0.01)
      finally:
          self.stop()
          self.wait()
    section: main_after_start
  states: {}
- name: grwifi_pdus
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: ieee80211_decode_0
  id: ieee80211_decode
  parameters:
    ifdebug: 'False'
  states: {}
- name: ieee80211_demod_0
  id: ieee80211_demod
  parameters:
    mugid: '2'
    mupos: '0'
  states: {}
- name: ieee80211_signal_0
  id: ieee80211_signal
  parameters: {}
  states: {}
- name: ieee80211_sync_0
  id: ieee80211_sync
  parameters: {}
  states: {}
- name: ieee80211_trigger_0
  id: ieee80211_trigger
  parameters: {}
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: kernel_dir
  id: parameter
  parameters:
    label: Baseline LS NPU build directory
    type: str
    value: '"../../base/kernel/build"'
  states: {}
- name: legacy_pdus
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: llr_flush
  id: blocks_stream_mux
  parameters:
    lengths: (llr_count, 8192)
    type: float
  states: {}
- name: llr_flush_zeros
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (0,)
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: kernel_dir + "/insts.bin"
    path_xclbin: kernel_dir + "/final.xclbin"
    weights_path: ''''''
  states: {}
- name: npu_pdus
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: prepare_check
  id: snippet
  parameters:
    code: |
      import hashlib
      import json
      from pathlib import Path
      import numpy as np
      if self.capture_meta['global']['core:sample_rate'] != 20000000:
          raise ValueError('Compatibility check requires 20 MHz I/Q')
      data = Path(self.capture_base + '.sigmf-data').read_bytes()
      if hashlib.sha512(data).hexdigest() != self.capture_meta['global']['core:sha512']:
          raise ValueError('SigMF checksum mismatch')
      samples = np.frombuffer(data, dtype='<c8')
      self.peak = float(max(np.max(np.abs(samples.real)), np.max(np.abs(samples.imag))))
      if not np.isfinite(samples).all() or self.peak >= 1:
          raise ValueError('Input does not fit unclipped Q15')
      self.expected = [json.loads(a['core:comment']) for a in self.capture_meta['annotations']]
      if not self.expected:
          raise ValueError('No expected frames')
      self.receivers = {'gr-ieee802-11': self.legacy_pdus, 'gr-ieee80211': self.grwifi_pdus, 'NPU-base-LS': self.npu_pdus}
    section: main_after_init
  states: {}
- name: presiso_0
  id: presiso
  parameters: {}
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: '20000000'
    chan_est: ieee802_11.LS
    encoding: ieee802_11.Encoding(0)
    frequency: freq
    sensitivity: '0.56'
  states: {}

connections:
- [blocks_file_source_0, '0', ieee80211_signal_0, '1']
- [blocks_file_source_0, '0', ieee80211_sync_0, '2']
- [blocks_file_source_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [blocks_file_source_0, '0', presiso_0, '0']
- [blocks_file_source_0, '0', wifi_phy_hier_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee80211_decode_0, out, grwifi_pdus, store]
- [ieee80211_demod_0, '0', llr_flush, '0']
- [ieee80211_signal_0, '0', ieee80211_demod_0, '0']
- [ieee80211_sync_0, '0', ieee80211_signal_0, '0']
- [ieee80211_trigger_0, '0', ieee80211_sync_0, '0']
- [ieee802_11_decode_mac_0, out, npu_pdus, store]
- [llr_flush, '0', ieee80211_decode_0, '0']
- [llr_flush_zeros, '0', llr_flush, '1']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [presiso_0, '0', ieee80211_trigger_0, '0']
- [presiso_0, '1', ieee80211_sync_0, '1']
- [wifi_phy_hier_0, '0', blocks_null_sink_0, '0']
- [wifi_phy_hier_0, mac_out, legacy_pdus, store]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
