options:
  parameters:
    generate_options: qt_gui
    id: rate_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '100'
    freq: '1005'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sys
      import os

      from aie.dialects.aie import *
      from aie.extras.context import mlir_mod_ctx
      from aie.iron import Program, Runtime, Worker, ObjectFifo
      from aie.iron.placers import SequentialPlacer
      from aie.iron.controlflow import range_

      import aie.iron as iron
      from aie.utils import NPUKernel, DefaultNPURuntime, get_current_device

       
      #DEV = AIEDevice.npu1
      DEV = iron.get_current_device()
      VECTOR_SIZE = 16384
      DTYPE=np.int8
          
      class blk(gr.sync_block):  

          def __init__(self, path_xclbin="kernel-compile/build/final.xclbin",path_insts_bin="kernel-compile/build/insts.bin"):  
              gr.sync_block.__init__(
                  self,
                  name='MLIR-AIE', 
                  in_sig=[DTYPE],
                  out_sig=[DTYPE]
              )
      		                
              npu_kernel = NPUKernel(
                  path_xclbin,
                  path_insts_bin,
                  kernel_name="MLIR_AIE",
              )
               
              self.kernel_handle = DefaultNPURuntime.load(npu_kernel)
              self.out_buf = iron.zeros(VECTOR_SIZE, dtype=DTYPE)
                      
          def work(self, input_items, output_items):
              if(len(input_items[0]) < VECTOR_SIZE):
                  return 0
      		
              buffers = [iron.tensor(input_items[0][:VECTOR_SIZE], dtype=DTYPE), self.out_buf] 
              DefaultNPURuntime.run(self.kernel_handle, buffers)        
              output_items[0][:VECTOR_SIZE] = self.out_buf.numpy()
              
              return VECTOR_SIZE
    path_insts_bin: '''/media/piloteer/SAMSUNG_EXT/XDNA/examples/grc-v2/kernel-compile/build/insts.bin'''
    path_xclbin: '''/media/piloteer/SAMSUNG_EXT/XDNA/examples/grc-v2/kernel-compile/build/final.xclbin'''
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_probe_rate_0, '0']
- [analog_sig_source_x_0, '0', epy_block_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [epy_block_0_1, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
