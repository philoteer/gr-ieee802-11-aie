options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fftlen
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '.99'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fftlen
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fftlen
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(fftlen)
  states: {}
- name: mlir_aie_cint32_to_complex64_0
  id: mlir_aie_cint32_to_complex64
  parameters:
    fractional_bits: '15'
    integer_bits: '16'
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_cpp_int32_to_int64_0
  id: mlir_aie_mlir_aie_cpp_int32_to_int64
  parameters:
    VECTOR_SIZE: '4096'
    kernel_name: MLIR_AIE
    path_insts_bin: build/insts.bin
    path_xclbin: build/final.xclbin
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: fftlen
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [analog_sig_source_x_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [mlir_aie_cint32_to_complex64_0, '0', qtgui_time_sink_x_0, '1']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_cpp_int32_to_int64_0, '0']
- [mlir_aie_mlir_aie_cpp_int32_to_int64_0, '0', mlir_aie_cint32_to_complex64_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
