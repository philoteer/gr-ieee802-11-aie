options:
  parameters:
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: mlir_aie_bfloat16_to_float32_0
  id: mlir_aie_bfloat16_to_float32
  parameters: {}
  states: {}
- name: mlir_aie_complex64_to_cbfloat_0
  id: mlir_aie_complex64_to_cbfloat
  parameters: {}
  states: {}
- name: mlir_aie_mlire_aie_cpp_int32_to_int16_0
  id: mlir_aie_mlire_aie_cpp_int32_to_int16
  parameters:
    VECTOR_SIZE: '4096'
    kernel_name: MLIR_AIE
    path_insts_bin: /home/piloteer/xdna_phy/gr-mlir-aie/aie-kernel-src/cpp_cbfloat16_arg_math_chesscc/build/insts.bin
    path_xclbin: /home/piloteer/xdna_phy/gr-mlir-aie/aie-kernel-src/cpp_cbfloat16_arg_math_chesscc/build/final.xclbin
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_complex_to_arg_0, '0']
- [analog_noise_source_x_0, '0', mlir_aie_complex64_to_cbfloat_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [mlir_aie_bfloat16_to_float32_0, '0', blocks_sub_xx_0, '1']
- [mlir_aie_bfloat16_to_float32_0, '0', qtgui_time_sink_x_0, '1']
- [mlir_aie_complex64_to_cbfloat_0, '0', mlir_aie_mlire_aie_cpp_int32_to_int16_0, '0']
- [mlir_aie_mlire_aie_cpp_int32_to_int16_0, '0', mlir_aie_bfloat16_to_float32_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
