options:
  parameters:
    id: npu_intra_kernel
    title: NPU Intra-Block Latency Profile
    description: Host-side stage timing inside the locally built NPU PHY block.
    category: Custom
    output_language: python
    generate_options: no_gui
    run_command: bash -c 'exec bash "$(dirname "$2")/run-profile.sh" "$1" -u "$2"' -- {python} {filename}
    run_options: run
    gen_cmake: 'Off'
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(globals().get('__file__', 'Experiments/latency_profile/npu_intra_kernel.py')).resolve().parents[2] / 'AI-model-CNN-Channel-est' / 'data')
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(data_dir).parents[1] / 'Experiments' / 'xclbin_default' / 'LS')
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {}
- name: output_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(__import__('os').environ.get('PROFILE_OUTPUT_DIR', str(__import__('pathlib').Path(globals().get('__file__', 'Experiments/latency_profile/npu_intra_kernel.py')).resolve().parent / 'results'))) / 'intra')
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: num_samples
  id: parameter
  parameters:
    label: Input complex samples (0 = entire file)
    type: intx
    default: '0'
    short_id: n
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path + '-data'
    type: short
    repeat: 'False'
    length: 2 * num_samples
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    type: complex
    metadata_file: file_path + '-meta'
    start_sample: '0'
    tag_key: rx_freq
  states: {}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    nominal_frequency: freq
    num_slots: '2'
    kernel_name: MLIR_AIE
    path_insts_bin: kernel_dir + '/insts.bin'
    path_xclbin: kernel_dir + '/final.xclbin'
    weights_path: ''''''
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: byte
    num_items: '48'
  states: {}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_dir + '/decoded.pcap'
    type: byte
    unbuffered: 'True'
  states: {}
- name: profile_start
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      import profiler_support
      self.profile_session = profiler_support.ProfileSession(self, 'intra', self.output_dir)
  states: {}
- name: create_output_directory
  id: snippet
  parameters:
    section: init_before_blocks
    code: __import__('pathlib').Path(self.output_dir).mkdir(parents=True, exist_ok=True)
  states: {}
- name: profile_finish
  id: snippet
  parameters:
    section: main_after_stop
    code: self.profile_session.finish()
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', mlir_aie_complex64_to_cint16_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
