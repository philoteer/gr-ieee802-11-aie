options:
  parameters:
    category: Custom
    description: Host-side stage timing inside the locally built NPU PHY block.
    gen_cmake: 'Off'
    generate_options: no_gui
    id: wifi_rx
    output_language: python
    run_command: bash -c 'exec bash "$(dirname "$2")/run-profile.sh" "$1" -u "$2"' -- {python} {filename}
    run_options: run
    title: NPU Intra-Block Latency Profile
  states: {}

blocks:
- name: data_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(globals().get('__file__', 'Experiments/latency_profile/npu_intra_kernel.py')).resolve().parents[2] / 'AI-model-CNN-Channel-est' / 'data')
  states: {}
- name: file_path
  id: variable
  parameters:
    value: data_dir + "/raw_capture/room_20260927.sigmf"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.417e9
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(data_dir).parents[1] / 'Experiments' / 'xclbin_default' / 'LS')
  states: {}
- name: kernel_dir
  id: variable
  parameters:
    value: '"./null_kernel/build"'
  states: {state: disabled}
- name: output_dir
  id: variable
  parameters:
    value: str(__import__('pathlib').Path(__import__('os').environ.get('PROFILE_OUTPUT_DIR', str(__import__('pathlib').Path(globals().get('__file__', 'Experiments/latency_profile/npu_intra_kernel.py')).resolve().parent / 'results'))) / 'intra')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_dir + '/decoded.pcap'
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_path + '-data'
    length: 2 * num_samples
    repeat: 'False'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '32768'
    vector_input: 'False'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '48'
    type: byte
  states: {state: disabled}
- name: create_output_directory
  id: snippet
  parameters:
    code: __import__('pathlib').Path(self.output_dir).mkdir(parents=True, exist_ok=True)
    section: init_before_blocks
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: ieee802_11_decode_mac_0
  id: ieee802_11_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {state: disabled}
- name: mlir_aie_complex64_to_cint16_0
  id: mlir_aie_complex64_to_cint16
  parameters:
    safe: 'False'
  states: {}
- name: mlir_aie_mlir_aie_80211_phy_0
  id: mlir_aie_mlir_aie_80211_phy
  parameters:
    N_TILES: '16'
    VECTOR_SIZE: '16384'
    kernel_name: MLIR_AIE
    nominal_frequency: freq
    num_slots: '2'
    path_insts_bin: kernel_dir + '/insts.bin'
    path_xclbin: kernel_dir + '/final.xclbin'
    weights_path: ''''''
  states: {}
- name: mlir_aie_sigmf_tag_injector_0
  id: mlir_aie_sigmf_tag_injector
  parameters:
    metadata_file: file_path + '-meta'
    start_sample: '0'
    tag_key: rx_freq
    type: complex
  states: {}
- name: num_samples
  id: parameter
  parameters:
    label: Input complex samples (0 = entire file)
    short_id: n
    type: intx
    value: '0'
  states: {}
- name: profile_finish
  id: snippet
  parameters:
    code: self.profile_session.finish()
    section: main_after_stop
  states: {}
- name: profile_start
  id: snippet
  parameters:
    code: |-
      import profiler_support
      self.profile_session = profiler_support.ProfileSession(self, self.output_dir)
    section: main_after_init
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_probe_rate_0, '0']
- [blocks_interleaved_short_to_complex_0, '0', mlir_aie_sigmf_tag_injector_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, log]
- [blocks_stream_to_vector_0, '0', ieee802_11_decode_mac_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [ieee802_11_decode_mac_0, out, foo_wireshark_connector_0, in]
- [ieee802_11_decode_mac_0, out, ieee802_11_parse_mac_0, in]
- [mlir_aie_complex64_to_cint16_0, '0', blocks_null_sink_0_0, '0']
- [mlir_aie_complex64_to_cint16_0, '0', mlir_aie_mlir_aie_80211_phy_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_null_sink_0, '0']
- [mlir_aie_mlir_aie_80211_phy_0, '0', blocks_stream_to_vector_0, '0']
- [mlir_aie_sigmf_tag_injector_0, '0', mlir_aie_complex64_to_cint16_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
