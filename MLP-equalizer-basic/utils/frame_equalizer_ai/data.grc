options:
  parameters:
    catch_exceptions: 'False'
    category: Custom
    description: Standards-block OFDM training data for the frame-equalizer neural demapper.
    generate_options: no_gui
    id: data
    output_language: python
    run_options: run
    title: Frame Equalizer AI Dataset Generator
  states: {}

blocks:
- name: configurations
  id: variable
  parameters:
    comment: Constellation size, encoding tag, coded bits per symbol, and AWGN amplitude.
    value: '{''bpsk'':(2,0,24,0.30),''qpsk'':(4,2,48,0.19),''qam16'':(16,4,96,0.09),''qam64'':(64,6,192,0.05)}'
  states: {}
- name: constellation_size
  id: variable
  parameters:
    value: configurations[modulation][0]
  states: {}
- name: encoding
  id: variable
  parameters:
    comment: GNU Radio IEEE 802.11 encoding index.
    value: configurations[modulation][1]
  states: {}
- name: frames
  id: variable
  parameters:
    comment: Number of independently tagged WiFi frames.
    value: int(__import__('os').environ.get('DATASET_FRAMES', '24'))
  states: {}
- name: ltf_words
  id: variable
  parameters:
    comment: Two standard shifted L-LTF vectors.
    value: (tuple((0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0)),)*2
  states: {}
- name: modulation
  id: variable
  parameters:
    comment: Selected legacy constellation.
    value: __import__('os').environ.get('DATASET_MODULATION', 'bpsk')
  states: {}
- name: noise_amplitude
  id: variable
  parameters:
    comment: Time-domain AWGN sigma, matched to test-learned-ber-basic.grc.
    value: configurations[modulation][3]
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    comment: Standard 48 legacy data subcarriers.
    value: (list(range(-26,-21))+list(range(-20,-7))+list(range(-6,0))+list(range(1,7))+list(range(8,21))+list(range(22,27)),)
  states: {}
- name: output_file
  id: variable
  parameters:
    comment: NPZ path consumed by dataset.py.
    value: __import__('os').environ.get('DATASET_OUTPUT', 'artifacts/dataset.npz')
  states: {}
- name: payload_tags
  id: variable
  parameters:
    comment: One packet_len/encoding/LENGTH tag set per payload frame.
    value: '(lambda p,n,s,e,l: [gr.tag_utils.python_to_tag((f*s*48,p.intern(k),v,p.PMT_NIL)) for f in range(n) for k,v in (("packet_len",p.from_long(s*48)),("encoding",p.from_long(e)),("psdu_len",p.from_long(l)),("wifi_start",p.from_double(0.0)))])(__import__(''pmt''),frames,symbols_per_frame,encoding,psdu_len)'
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    comment: Standard 127-symbol IEEE 802.11 pilot polarity sequence.
    value: tuple((p,p,p,-p) for p in (1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,1,1,-1,1,-1,-1,1,1,-1,1,1,-1,1,1,1,1,1,1,-1,1,1,1,-1,1,1,-1,-1,1,1,1,-1,1,-1,-1,-1,1,-1,1,-1,-1,1,-1,-1,1,1,1,1,1,-1,-1,1,1,-1,-1,1,-1,1,-1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,1,-1,1,1,1,1,-1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,1,1,-1,1,-1,1,1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1))
  states: {}
- name: psdu_len
  id: variable
  parameters:
    comment: Valid LENGTH whose encoded payload occupies symbols_per_frame symbols.
    value: max(0,(symbols_per_frame*configurations[modulation][2]-22)//8)
  states: {}
- name: seed
  id: variable
  parameters:
    comment: Seed for labels, fading, and AWGN.
    value: int(__import__('os').environ.get('DATASET_SEED', '39'))
  states: {}
- name: signal_formatter
  id: variable
  parameters:
    comment: GNU Radio IEEE 802.11 RATE/LENGTH encoder and interleaver.
    value: ieee802_11.signal_field()
  states: {}
- name: symbols_per_frame
  id: variable
  parameters:
    comment: Labeled payload OFDM symbols per frame.
    value: int(__import__('os').environ.get('DATASET_SYMBOLS_PER_FRAME', '2'))
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: carrier_allocator
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    comment: Add two L-LTF vectors, pilots, guards, and standard carrier placement.
    fft_len: '64'
    len_tag_key: packet_len
    occupied_carriers: occupied_carriers
    output_is_shifted: 'True'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: pilot_symbols
    sync_words: ltf_words
  states: {}
- name: channel_gain
  id: blocks_multiply_const_xx
  parameters:
    comment: Leave fixed-point headroom as in the BER benchmark.
    const: '0.5'
    type: complex
  states: {}
- name: cyclic_prefixer
  id: digital_ofdm_cyclic_prefixer
  parameters:
    comment: Add the standard 16-sample cyclic prefix.
    cp_len: '16'
    input_size: '64'
    tagname: '""'
  states: {}
- name: fading
  id: channels_selective_fading_model
  parameters:
    K: '8.0'
    LOS: 'True'
    N: '8'
    comment: Seeded time-varying selective fading shared across each waveform.
    delays: (0.0,3.0,8.0)
    fDTs: 40.0/20e6
    mags: (1.0,0.35,0.2)
    ntaps: '16'
    seed: seed+50
  states: {}
- name: feature_extractor
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      LONG = np.asarray(
          [0,0,0,0,0,0,1,1,-1,-1,1,1,-1,1,-1,1,
           1,1,1,1,1,-1,-1,1,1,-1,1,-1,1,1,1,1,
           0,1,-1,-1,1,1,-1,1,-1,1,-1,-1,-1,-1,-1,
           1,1,-1,-1,1,-1,1,-1,1,1,1,1,0,0,0,0,0], np.complex64)
      OCCUPIED_BINS = np.asarray([i for i in range(6, 59) if i != 32])
      PILOT_POLARITY = (1,1,1,1,-1,-1,-1,1,-1,-1,-1,-1,1,1,-1,1,
          -1,-1,1,1,-1,1,1,-1,1,1,1,1,1,1,-1,1,1,1,-1,1,1,-1,-1,
          1,1,1,-1,1,-1,-1,-1,1,-1,1,-1,-1,1,-1,-1,1,1,1,1,1,-1,
          -1,1,1,-1,-1,1,-1,1,-1,1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,
          -1,-1,1,-1,1,1,1,1,-1,1,-1,1,-1,1,-1,-1,-1,-1,-1,1,-1,
          1,1,-1,1,-1,1,1,1,-1,-1,1,-1,-1,-1,1,1,1,-1,-1,-1,-1,-1,-1,-1)

      class blk(gr.sync_block):
          """Expose matched-filter features not available from standard blocks."""

          def __init__(self, symbols_per_frame=2):
              gr.sync_block.__init__(
                  self,
                  name='matched-filter feature extractor',
                  in_sig=[(np.complex64, 64)],
                  out_sig=[(np.float32, 192)],
              )
              self.frame_vectors = int(symbols_per_frame) + 3
              self.position = 0
              self.first_ltf = None
              self.h_est = np.zeros(64, np.complex64)

          def work(self, input_items, output_items):
              for index, received in enumerate(input_items[0]):
                  received = received.copy()
                  if self.position < 2:
                      pilots = np.asarray([
                          received[11], -received[25], received[39], received[53]])
                  else:
                      polarity = PILOT_POLARITY[(self.position - 2) % len(PILOT_POLARITY)]
                      pilots = polarity * np.asarray([
                          received[11], received[25], received[39], -received[53]])
                  received *= np.exp(-1j * np.angle(np.sum(pilots)))

                  if self.position == 0:
                      self.first_ltf = received.copy()
                  elif self.position == 1:
                      self.h_est.fill(0)
                      self.h_est[OCCUPIED_BINS] = (
                          self.first_ltf[OCCUPIED_BINS] + received[OCCUPIED_BINS]
                      ) / (2.0 * LONG[OCCUPIED_BINS])

                  matched = received * np.conj(self.h_est)
                  h2 = np.abs(self.h_est) ** 2
                  raw = np.stack((matched.real, matched.imag, h2), axis=-1)
                  normalized = np.empty_like(raw, dtype=np.float32)
                  for base in range(0, 64, 16):
                      block = raw[base:base + 16]
                      exponent = np.frexp(max(float(np.max(np.abs(block))), 1e-12))[1]
                      normalized[base:base + 16] = block / np.ldexp(1.0, exponent)
                  output_items[0][index] = normalized.reshape(-1)
                  self.position = (self.position + 1) % self.frame_vectors
              return len(input_items[0])
    comment: Only custom DSP block; standard GNU Radio blocks do not expose Y*conj(H) and abs(H)^2.
    symbols_per_frame: symbols_per_frame
  states: {}
- name: feature_sink
  id: blocks_vector_sink_x
  parameters:
    comment: All frame vectors; the final snippet selects payload vectors.
    reserve_items: frames*(symbols_per_frame+3)
    type: float
    vlen: '192'
  states: {}
- name: fft_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: Undo the transmitter-side normalization.
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: hardware_impairments
  id: channels_impairments
  parameters:
    beta: '0.018'
    comment: GNU Radio phase/frequency-selective hardware impairment model.
    freq_offset: '0.0'
    gamma: '0.0'
    i_ofs: '0.0'
    magbal: '0.25'
    phase_noise_mag: '0.0'
    phasebal: '3.0'
    q_ofs: '0.0'
  states: {}
- name: header_payload_mux
  id: blocks_tagged_stream_mux
  parameters:
    comment: Prefix one SIGNAL symbol to every payload packet.
    lengthtagname: packet_len
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: ifft
  id: fft_vxx
  parameters:
    comment: Standard shifted 64-point OFDM IFFT.
    fft_size: '64'
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: ifft_scale
  id: blocks_multiply_const_xx
  parameters:
    comment: Match the normalization used by the frame-equalizer BER graph.
    const: 1/8.0
    type: complex
    vlen: '64'
  states: {}
- name: label_head
  id: blocks_head
  parameters:
    comment: Bound the continuous random source to the requested corpus.
    num_items: frames*symbols_per_frame*48
    type: byte
  states: {}
- name: label_source
  id: analog_random_uniform_source_x
  parameters:
    comment: Standard seeded random constellation labels.
    maximum: constellation_size
    minimum: '0'
    seed: seed+1
    type: byte
  states: {}
- name: label_tag_share
  id: blocks_tag_share
  parameters:
    comment: Attach packet metadata without replacing random labels.
    io_type: byte
    share_type: byte
  states: {}
- name: noise_source
  id: analog_noise_source_x
  parameters:
    amp: noise_amplitude
    comment: Seeded complex Gaussian noise.
    noise_type: analog.GR_GAUSSIAN
    seed: seed+101
    type: complex
  states: {}
- name: payload_mapper
  id: ieee802_11_chunks_to_symbols_xx
  parameters:
    comment: Standard per-packet WiFi constellation mapper.
  states: {}
- name: remove_cp
  id: blocks_keep_m_in_n
  parameters:
    comment: Remove 16 samples from each 80-sample OFDM symbol.
    m: '64'
    n: '80'
    offset: '16'
    type: complex
  states: {}
- name: rx_fft
  id: fft_vxx
  parameters:
    comment: Standard shifted 64-point receiver FFT.
    fft_size: '64'
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: save_dataset
  id: snippet
  parameters:
    code: |-
      from pathlib import Path
      import numpy as np

      data_bins = np.asarray([i for i in range(6, 59)
                              if i not in (11, 25, 32, 39, 53)])
      bit_counts = {'bpsk': 1, 'qpsk': 2, 'qam16': 4, 'qam64': 6}
      frame_vectors = self.symbols_per_frame + 3
      all_features = np.asarray(self.feature_sink.data(), dtype=np.float32).reshape(
          self.frames, frame_vectors, 64, 3)
      full_features = all_features[:, 3:, :, :].reshape(-1, 64, 3)
      classes = np.asarray(self.truth_sink.data(), dtype=np.uint8).astype(np.int64)
      expected = self.frames * self.symbols_per_frame * 48
      if classes.size != expected:
          raise RuntimeError(f'truth stream has {classes.size} labels; expected {expected}')
      features = full_features[:, data_bins, :].reshape(-1, 3)
      labels = ((classes[:, None] >> np.arange(bit_counts[self.modulation])) & 1).astype(
          np.float32)
      output = Path(self.output_file)
      output.parent.mkdir(parents=True, exist_ok=True)
      np.savez(output, features=features, labels=labels, classes=classes,
               full_features=full_features)
    comment: Select payload vectors, pair them with source labels, and write NPZ.
    section: main_after_stop
  states: {}
- name: signal_bpsk
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Map generated SIGNAL decisions to BPSK.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: signal_header
  id: digital_packet_headergenerator_bb
  parameters:
    comment: Generate and interleave each standards-compliant SIGNAL field.
    header_formatter: signal_formatter.formatter()
    len_tag_key: packet_len
  states: {}
- name: stream_to_vector
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: complex
  states: {}
- name: tag_carrier
  id: blocks_vector_source_x
  parameters:
    comment: Finite dummy stream carrying packet metadata.
    repeat: 'False'
    tags: payload_tags
    type: byte
    vector: '[0]*(frames*symbols_per_frame*48)'
  states: {}
- name: truth_sink
  id: blocks_vector_sink_x
  parameters:
    comment: Preserve labels before modulation.
    reserve_items: frames*symbols_per_frame*48
    type: byte
  states: {}

connections:
- [add_noise, '0', remove_cp, '0']
- [carrier_allocator, '0', ifft, '0']
- [channel_gain, '0', add_noise, '0']
- [cyclic_prefixer, '0', hardware_impairments, '0']
- [fading, '0', channel_gain, '0']
- [feature_extractor, '0', feature_sink, '0']
- [fft_scale, '0', feature_extractor, '0']
- [hardware_impairments, '0', fading, '0']
- [header_payload_mux, '0', carrier_allocator, '0']
- [ifft, '0', ifft_scale, '0']
- [ifft_scale, '0', cyclic_prefixer, '0']
- [label_head, '0', label_tag_share, '0']
- [label_source, '0', label_head, '0']
- [label_tag_share, '0', payload_mapper, '0']
- [label_tag_share, '0', signal_header, '0']
- [label_tag_share, '0', truth_sink, '0']
- [noise_source, '0', add_noise, '1']
- [payload_mapper, '0', header_payload_mux, '1']
- [remove_cp, '0', stream_to_vector, '0']
- [rx_fft, '0', fft_scale, '0']
- [signal_bpsk, '0', header_payload_mux, '0']
- [signal_header, '0', signal_bpsk, '0']
- [stream_to_vector, '0', rx_fft, '0']
- [tag_carrier, '0', label_tag_share, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
